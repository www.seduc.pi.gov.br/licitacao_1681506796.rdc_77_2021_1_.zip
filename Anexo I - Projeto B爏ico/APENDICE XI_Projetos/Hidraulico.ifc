Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-06-16T12:48:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.11.27 - Exporter 21.1.11.27 - IU alternativa 21.1.11.27
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 16 12:48:13 2021 * Host: LAPTOP-D06TDN94 * Database: C:\Users\PAULAT~1\AppData\Local\Temp\4635c08b-ae0a-4f26-9cb2-6a9597644325\61a2bb25-3ad8-49f4-8ca0-2522639f3b3c\ifc * Database version: 5507 * Database creation date: Wed Jun 16 12:47:53 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 16 12:47:54 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 16 12:47:54 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 m

# IfcBuilding, C.L. MONSENHOR ANTÔNIO SAMPAIO
LongName: C.L. MONSENHOR ANTÔNIO SAMPAIO
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Nível:8 mm Extremidade superior, Nível 1
In: C.L. MONSENHOR ANTÔNIO SAMPAIO
LongName: Nível 1; Elevation: 1.2 m

# IfcDistributionPort (768)
Description: Flow
Name | FlowDirection | Group
Port_1211605 | SINK
Port_1211606 | SINK
Port_1211607 | SINK
Port_1212720 | SINK
Port_1212721 | SINK
Port_1212722 | SINK
Port_1212723 | SINK
Port_1212724 | SINK
Port_1212726 | SINK
Port_1212727 | SINK
Port_1212728 | SINK
Port_1212730 | SINK
Port_1220911 | SOURCE
Port_1220911 | SINK
Port_1220915 | SINK
Port_1220915 | SOURCE
Port_1220918 | SOURCE
Port_1220918 | SINK
Port_1220921 | SOURCE
Port_1220921 | SINK
Port_1220924 | SINK
Port_1220924 | SOURCE
Port_1220930 | SOURCE
Port_1220930 | SINK
3 x Port_1233198 | SINK
4 x Port_1233198 | SOURCE
4 x Port_1233201 | SOURCE
3 x Port_1233201 | SINK
Port_1233204 | SINK
Port_1233204 | SOURCE
Port_1233207 | SINK
Port_1233207 | SOURCE
Port_1233210 | SINK
Port_1233210 | SOURCE
Port_1233213 | SOURCE
Port_1233213 | SINK
Port_1233216 | SOURCE
Port_1233216 | SINK
Port_1233219 | SOURCE
Port_1233219 | SINK
Port_1233222 | SOURCE
Port_1233222 | SINK
Port_1233225 | SOURCE
Port_1233225 | SINK
Port_1233228 | SINK
Port_1233228 | SOURCE
Port_1233231 | SINK
Port_1233231 | SOURCE
Port_1236532 | SINK
Port_1236533 | SINK
Port_1236534 | SINK
Port_1236535 | SINK
Port_1236536 | SINK
Port_1236537 | SINK
Port_1238621 | SOURCE
Port_1238622 | SINK
Port_1238622 | SOURCE
Port_1238625 | SINK
Port_1238626 | SOURCE
Port_1238627 | SOURCE
Port_1238627 | SINK
Port_1238634 | SINK
Port_1238635 | SOURCE
Port_1238635 | SINK
Port_1238638 | SINK
Port_1238639 | SOURCE
Port_1238639 | SINK
Port_1240618 | SINK
2 x Port_1243413 | SOURCE
Port_1243413 | SOURCEANDSINK
Port_1243413 | SINK
Port_1243414 | SINK
2 x Port_1243414 | SOURCE
Port_1243414 | SOURCEANDSINK
Port_1243415 | SOURCEANDSINK
2 x Port_1243415 | SOURCE
Port_1243415 | SINK
2 x Port_1243416 | SOURCE
Port_1243416 | SINK
Port_1243416 | SOURCEANDSINK
2 x Port_1243417 | SOURCE
Port_1243417 | SOURCEANDSINK
Port_1243417 | SINK
2 x Port_1243418 | SOURCE
Port_1243418 | SOURCEANDSINK
Port_1243418 | SINK
2 x Port_1243419 | SOURCE
Port_1243419 | SOURCEANDSINK
Port_1243419 | SINK
2 x Port_1243420 | SOURCE
Port_1243420 | SOURCEANDSINK
Port_1243420 | SINK
2 x Port_1243421 | SOURCE
Port_1243421 | SINK
Port_1243421 | SOURCEANDSINK
Port_1243422 | SOURCEANDSINK
Port_1243422 | SINK
2 x Port_1243422 | SOURCE
2 x Port_1243530 | SINK
6 x Port_1243530 | SOURCEANDSINK
InPort_1248568 | SINK | Água fria doméstica 3
OutPort_1243530 | SOURCE | Água fria doméstica 3
InPort_1249038 | SINK | Água fria doméstica 1
OutPort_1243530 | SOURCE | Água fria doméstica 1
InPort_1243530 | SOURCEANDSINK | Água fria doméstica 1
OutPort_1248962 | SOURCEANDSINK | Água fria doméstica 1
InPort_1248464 | SINK | Água fria doméstica 2
OutPort_1243530 | SOURCE | Água fria doméstica 2
Port_1243531 | SOURCE
2 x InPort_1243901 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1243949 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244505 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1243930 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1243950 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245376 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1243939 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1243988 | SOURCEANDSINK | Água fria doméstica 2
InPort_1243949 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1243985 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244001 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244347 | SOURCEANDSINK | Água fria doméstica 2
InPort_1243988 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244924 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1243993 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244011 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1244005 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244021 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244068 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244011 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244109 | SOURCEANDSINK | Água fria doméstica 2
Port_1244021 | SOURCEANDSINK | Água fria doméstica 2
Port_1244060 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244060 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244068 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244069 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244069 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244089 | SOURCEANDSINK | Água fria doméstica 2
Port_1244081 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244081 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244089 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244090 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244090 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244108 | SOURCEANDSINK | Água fria doméstica 2
Port_1244100 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244100 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244108 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1244347 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244379 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244348 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244348 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244922 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244379 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244393 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1244387 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244420 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244403 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244393 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244440 | SOURCEANDSINK | Água fria doméstica 2
Port_1244395 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244395 | SOURCEANDSINK | Água fria doméstica 2
Port_1244412 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244412 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244420 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244421 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244421 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244439 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244431 | SOURCEANDSINK | Água fria doméstica 2
Port_1244431 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244439 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1244493 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244518 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1244515 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245056 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1244522 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244548 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244536 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244536 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244798 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1244540 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244556 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244615 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244548 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1244616 | SOURCEANDSINK | Água fria doméstica 2
Port_1244556 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1244612 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244625 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244615 | SOURCEANDSINK | Água fria doméstica 2
Port_1244625 | SOURCEANDSINK | Água fria doméstica 2
3 x InPort_1244797 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244830 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245058 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244830 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1244844 | SOURCEANDSINK | Água fria doméstica 2
Port_1244844 | SOURCEANDSINK | Água fria doméstica 2
InPort_1244922 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245056 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245176 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245182 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245246 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245178 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245422 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245497 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245180 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245188 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245182 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245183 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245183 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245496 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245186 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245218 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245192 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245188 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245279 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245190 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245196 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245194 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245198 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245202 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245196 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245215 | SOURCEANDSINK | Água fria doméstica 2
Port_1245198 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245200 | SOURCEANDSINK | Água fria doméstica 2
Port_1245200 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245202 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245203 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245203 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245208 | SOURCEANDSINK | Água fria doméstica 2
Port_1245206 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245206 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245208 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245209 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245209 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245214 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245212 | SOURCEANDSINK | Água fria doméstica 2
Port_1245212 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245214 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245218 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245222 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245219 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245219 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245278 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245222 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245226 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245224 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245234 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245230 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245226 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245241 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245228 | SOURCEANDSINK | Água fria doméstica 2
Port_1245228 | SOURCEANDSINK | Água fria doméstica 2
Port_1245232 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245232 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245234 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245235 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245235 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245240 | SOURCEANDSINK | Água fria doméstica 2
Port_1245238 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245238 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245240 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245244 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245250 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245248 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245281 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245252 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245254 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245258 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245254 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245271 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245256 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245260 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245264 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245258 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245265 | SOURCEANDSINK | Água fria doméstica 2
Port_1245260 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245262 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245268 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245264 | SOURCEANDSINK | Água fria doméstica 2
Port_1245268 | SOURCEANDSINK | Água fria doméstica 2
3 x InPort_1245270 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245274 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245282 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245274 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245276 | SOURCEANDSINK | Água fria doméstica 2
Port_1245276 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245278 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245281 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245348 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1248755 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245366 | SOURCEANDSINK | Água fria doméstica 2
3 x InPort_1245366 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245827 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245490 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245599 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245496 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245596 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245787 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245603 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245660 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245621 | SOURCEANDSINK | Água fria doméstica 2
Port_1245621 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245660 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245671 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245789 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245671 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245687 | SOURCEANDSINK | Água fria doméstica 2
Port_1245687 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245787 | SOURCEANDSINK | Água fria doméstica 2
InPort_1245827 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245843 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245835 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1245889 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245881 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1245911 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245911 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246174 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246189 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245995 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246010 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1246408 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1245998 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246410 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246002 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1246022 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246014 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246086 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246036 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246022 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246087 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246033 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1246046 | SOURCEANDSINK | Água fria doméstica 2
Port_1246046 | SOURCEANDSINK | Água fria doméstica 2
Port_1246078 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246078 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246086 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246139 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246145 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1246281 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246141 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246286 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246143 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1246149 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246147 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246153 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246159 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246149 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246160 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246151 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1246155 | SOURCEANDSINK | Água fria doméstica 2
Port_1246155 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246157 | SOURCEANDSINK | Água fria doméstica 2
Port_1246157 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246159 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246281 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246408 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246504 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1248777 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246886 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246514 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246543 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246522 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246553 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246545 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246564 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246561 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1246776 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246568 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1246586 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1246614 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246574 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246634 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246778 | SOURCEANDSINK | Água fria doméstica 2
Port_1246586 | SOURCEANDSINK | Água fria doméstica 2
Port_1246614 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246614 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1246615 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246615 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246633 | SOURCEANDSINK | Água fria doméstica 2
Port_1246625 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246625 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246633 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246776 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246886 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1246898 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246898 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246919 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246916 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246931 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246923 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246950 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246947 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246962 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246954 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1246972 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246966 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247110 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247761 | SOURCEANDSINK | Água fria doméstica 2
InPort_1246972 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1246991 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246984 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1246990 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247010 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1246990 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247111 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247010 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247012 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247012 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247040 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247037 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247484 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247044 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247052 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247062 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247052 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247486 | SOURCEANDSINK | Água fria doméstica 2
Port_1247056 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247056 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247104 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247135 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247110 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247135 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247137 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247137 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247197 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247194 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247209 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247592 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247197 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247594 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247201 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247258 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247376 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247209 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247377 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247255 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247270 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247262 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247283 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247328 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247270 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247329 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247280 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247293 | SOURCEANDSINK | Água fria doméstica 2
Port_1247287 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247287 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247320 | SOURCEANDSINK | Água fria doméstica 2
Port_1247320 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247328 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247373 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247678 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247388 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247376 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247680 | SOURCEANDSINK | Água fria doméstica 2
Port_1247380 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247380 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247484 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247592 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247678 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247753 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247771 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247763 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247781 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247781 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247798 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247798 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1248105 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247812 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1248014 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247819 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247839 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247860 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1247825 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1247901 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1248016 | SOURCEANDSINK | Água fria doméstica 2
Port_1247839 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247860 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247861 | SOURCEANDSINK | Água fria doméstica 2
Port_1247860 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247861 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247881 | SOURCEANDSINK | Água fria doméstica 2
Port_1247881 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247881 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247882 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247882 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1247900 | SOURCEANDSINK | Água fria doméstica 2
Port_1247900 | SOURCEANDSINK | Água fria doméstica 2
InPort_1247900 | SOURCEANDSINK | Água fria doméstica 2
InPort_1248014 | SOURCEANDSINK | Água fria doméstica 2
InPort_1248105 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1248116 | SOURCEANDSINK | Água fria doméstica 2
InPort_1248116 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1248132 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1248126 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1248151 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1248148 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1248306 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1248155 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1248190 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1248173 | SOURCEANDSINK | Água fria doméstica 2
2 x InPort_1248163 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1248191 | SOURCEANDSINK | Água fria doméstica 2
2 x OutPort_1248308 | SOURCEANDSINK | Água fria doméstica 2
Port_1248173 | SOURCEANDSINK | Água fria doméstica 2
Port_1248190 | SOURCEANDSINK | Água fria doméstica 2
InPort_1248190 | SOURCEANDSINK | Água fria doméstica 2
InPort_1248306 | SOURCEANDSINK | Água fria doméstica 2
InPort_1248481 | SINK | Água fria doméstica 2
OutPort_1248464 | SOURCE | Água fria doméstica 2
InPort_1248759 | SINK | Água fria doméstica 2
OutPort_1248473 | SOURCE | Água fria doméstica 2
InPort_1248473 | SINK | Água fria doméstica 2
OutPort_1248481 | SOURCE | Água fria doméstica 2
InPort_1248588 | SINK | Água fria doméstica 3
OutPort_1248568 | SOURCE | Água fria doméstica 3
InPort_1248577 | SINK | Água fria doméstica 3
OutPort_1248588 | SOURCE | Água fria doméstica 3
InPort_1252060 | SINK | Água fria doméstica 3
OutPort_1248577 | SOURCE | Água fria doméstica 3
InPort_1248747 | SINK | Água fria doméstica 2
OutPort_1248759 | SOURCE | Água fria doméstica 2
InPort_1248755 | SINK | Água fria doméstica 2
OutPort_1248747 | SOURCE | Água fria doméstica 2
InPort_1248755 | SOURCEANDSINK | Água fria doméstica 2
OutPort_1248756 | SOURCEANDSINK | Água fria doméstica 2
InPort_1248756 | SOURCEANDSINK | Água fria doméstica 2
InPort_1248962 | SOURCEANDSINK | Água fria doméstica 1
2 x OutPort_1249043 | SOURCEANDSINK | Água fria doméstica 1
2 x InPort_1249021 | SOURCEANDSINK | Água fria doméstica 1
OutPort_1249037 | SOURCEANDSINK | Água fria doméstica 1
InPort_1249037 | SINK | Água fria doméstica 1
OutPort_1249038 | SOURCE | Água fria doméstica 1
InPort_1249037 | SOURCEANDSINK | Água fria doméstica 1
OutPort_1249051 | SOURCEANDSINK | Água fria doméstica 1
Port_1249051 | SOURCEANDSINK | Água fria doméstica 1
InPort_1250185 | SINK | Água fria doméstica 3
OutPort_1250189 | SOURCE | Água fria doméstica 3
InPort_1250212 | SINK | Água fria doméstica 3
OutPort_1250185 | SOURCE | Água fria doméstica 3
InPort_1250187 | SINK | Água fria doméstica 3
OutPort_1252056 | SOURCE | Água fria doméstica 3
InPort_1250204 | SINK | Água fria doméstica 3
OutPort_1250187 | SOURCE | Água fria doméstica 3
InPort_1250189 | SINK | Água fria doméstica 3
OutPort_1250210 | SOURCE | Água fria doméstica 3
InPort_1250202 | SINK | Água fria doméstica 3
OutPort_1250199 | SOURCE | Água fria doméstica 3
InPort_1250199 | SINK | Água fria doméstica 3
OutPort_1250207 | SOURCE | Água fria doméstica 3
InPort_1250200 | SINK | Água fria doméstica 3
OutPort_1250202 | SOURCE | Água fria doméstica 3
InPort_1250209 | SINK | Água fria doméstica 3
OutPort_1250200 | SOURCE | Água fria doméstica 3
InPort_1250205 | SINK | Água fria doméstica 3
OutPort_1250204 | SOURCE | Água fria doméstica 3
InPort_1250207 | SINK | Água fria doméstica 3
OutPort_1250205 | SOURCE | Água fria doméstica 3
InPort_1250210 | SINK | Água fria doméstica 3
OutPort_1250209 | SOURCE | Água fria doméstica 3
Port_1250212 | SINK | Água fria doméstica 3
InPort_1252035 | SINK | Água fria doméstica 3
OutPort_1252060 | SOURCE | Água fria doméstica 3
InPort_1252058 | SINK | Água fria doméstica 3
OutPort_1252035 | SOURCE | Água fria doméstica 3
InPort_1252056 | SINK | Água fria doméstica 3
OutPort_1252054 | SOURCE | Água fria doméstica 3
InPort_1252054 | SINK | Água fria doméstica 3
OutPort_1252058 | SOURCE | Água fria doméstica 3

# IfcFlowController: Adaptador com Anel - Agua Fria_Soldavel - MEP - Tigre:Standard (2)
In: Nível 1
Type - Material: PVC Marrom
Type - Pset_DistributionFlowElementCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Standard
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Adaptador com Anel - Agua Fria_Soldavel - MEP - Tigre:Standard:...)
1243533
1243534

# IfcFlowController: Adaptador com Registro - Agua Fria_Soldavel - MEP - Tigre:Standard (4)
In: Nível 1
Type - Material: PVC Marrom, Phenolic Resin
Type - Pset_DistributionFlowElementCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Standard
Material: Phenolic Resin, PVC Marrom
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Adaptador com Registro - Agua Fria_Soldavel - MEP - Tigre:Standard:...)
1243537
1243539
1248638
1248643

# IfcFlowController: Adaptador com Registro - Agua Fria_Soldavel - MEP - Tigre:Standard (5)
In: Nível 1
Type - Material: Phenolic Resin, PVC Marrom
Type - Pset_DistributionFlowElementCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Standard
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Adaptador com Registro - Agua Fria_Soldavel - MEP - Tigre:Standard:...)
1243532
1243536
1243538
1248898
1248903

# IfcFlowController: Hidrometro-simples com conectores:25x25mm, Hidrometro-simples com conectores:25x25mm:1250199
In: Nível 1
Type - Material: PVC, Flexible, Plastic, Opaque Black (2), Laminate, Navy
Type - Pset_DistributionFlowElementCommon - Reference: 25x25mm
Type - Pset_QuantityTakeOff - Reference: 25x25mm
Material: PVC, Flexible, Plastic, Opaque Black, Laminate, Navy; Group: Água fria doméstica 3
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowController: Registro Esfera VS - Agua Fria - MEP - Tigre:Soldável - 32 mm (2)
In: Nível 1
Type - Material: Phenolic Resin, PVC Marrom
Type - Pset_DistributionFlowElementCommon - Reference: Soldável - 32 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Soldável - 32 mm
Pset_DistributionFlowElementCommon - sets with these values: 2
Group: Água fria doméstica 3
Name (Registro Esfera VS - Agua Fria - MEP - Tigre:Soldável - 32 mm:...)
1250204
1250209

# IfcFlowController: Registro de Chuveiro - Agua Fria - MEP - Tigre:PVC Areia - 25 mm, Registro de Chuveiro - Agua Fria - MEP - Tigre:PVC Areia - 25 mm:1247678
In: Nível 1
Type - Material: PVC Areia (2), PVC Branco_01
Type - Pset_DistributionFlowElementCommon - Reference: PVC Areia - 25 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: PVC Areia - 25 mm
Material: PVC Areia, PVC Branco_01; Group: Água fria doméstica 2
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowController: Registro de Gaveta - Agua Fria - MEP - Tigre:PVC Areia - 25 mm (2)
In: Nível 1
Type - Material: PVC Areia (2), PVC Branco_01
Type - Pset_DistributionFlowElementCommon - Reference: PVC Areia - 25 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: PVC Areia - 25 mm
Material: PVC Branco_01, PVC Areia; Group: Água fria doméstica 2
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Registro de Gaveta - Agua Fria - MEP - Tigre:PVC Areia - 25 mm:...)
1245278
1245281

# IfcFlowController: Registro de Gaveta - Agua Fria - MEP - Tigre:PVC Areia - 25 mm (10)
In: Nível 1
Type - Material: PVC Branco_01, PVC Areia (2)
Type - Pset_DistributionFlowElementCommon - Reference: PVC Areia - 25 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: PVC Areia - 25 mm
Material: PVC Branco_01, PVC Areia; Group: Água fria doméstica 2
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Registro de Gaveta - Agua Fria - MEP - Tigre:PVC Areia - 25 mm:...)
1244922
1245056
1245787
1246281
1246408
1246776
1247484
1247592
1248014
1248306

# IfcFlowFitting: Bucha de Reducao Curta - Agua Fria_Soldavel - MEP - Tigre:Standard (2)
In: Nível 1
Type - Material: PVC Marrom
Type - Pset_DistributionFlowElementCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Standard
Pset_DistributionFlowElementCommon - sets with these values: 2
Group: Água fria doméstica 3
Name (Bucha de Reducao Curta - Agua Fria_Soldavel - MEP - Tigre:Standard:...)
1250202
1250207

# IfcFlowFitting: Bucha de Reducao Longa - Agua Fria_Soldavel - MEP - Tigre:Standard (7)
In: Nível 1
Type - Material: PVC Marrom
Type - Pset_DistributionFlowElementCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Standard
Pset_DistributionFlowElementCommon - sets with these values: 2
Group: Água fria doméstica 2
Name (Bucha de Reducao Longa - Agua Fria_Soldavel - MEP - Tigre:Standard:...)
1243930
1245178
1245889
1246543
1247010
1247135
1247781

# IfcFlowFitting: Cruzeta - Agua Fria_Soldavel - MEP - Tigre:Standard, Cruzeta - Agua Fria_Soldavel - MEP - Tigre:Standard:1245366
In: Nível 1
Type - Material: PVC Marrom
Type - Pset_DistributionFlowElementCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Standard
Pset_DistributionFlowElementCommon - sets with these values: 2
Group: Água fria doméstica 2

# IfcFlowFitting: Joelho 45_90 - Agua Fria_Soldavel - MEP - Tigre:Standard (57)
In: Nível 1
Type - Material: PVC Marrom
Type - Pset_DistributionFlowElementCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Standard
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Joelho 45_90 - Agua Fria_Soldavel - MEP - Tigre:Standard:...) | Group
1243988 | Água fria doméstica 2
1244001 | Água fria doméstica 2
1244011 | Água fria doméstica 2
1244393 | Água fria doméstica 2
1244505 | Água fria doméstica 2
1244518 | Água fria doméstica 2
1244536 | Água fria doméstica 2
1244548 | Água fria doméstica 2
1245188 | Água fria doméstica 2
1245192 | Água fria doméstica 2
1245196 | Água fria doméstica 2
1245226 | Água fria doméstica 2
1245246 | Água fria doméstica 2
1245250 | Água fria doméstica 2
1245254 | Água fria doméstica 2
1245258 | Água fria doméstica 2
1245599 | Água fria doméstica 2
1245843 | Água fria doméstica 2
1245998 | Água fria doméstica 2
1246010 | Água fria doméstica 2
1246022 | Água fria doméstica 2
1246036 | Água fria doméstica 2
1246141 | Água fria doméstica 2
1246145 | Água fria doméstica 2
1246149 | Água fria doméstica 2
1246153 | Água fria doméstica 2
1246553 | Água fria doméstica 2
1246564 | Água fria doméstica 2
1246574 | Água fria doméstica 2
1246919 | Água fria doméstica 2
1246931 | Água fria doméstica 2
1246950 | Água fria doméstica 2
1246962 | Água fria doméstica 2
1246972 | Água fria doméstica 2
1247040 | Água fria doméstica 2
1247052 | Água fria doméstica 2
1247197 | Água fria doméstica 2
1247209 | Água fria doméstica 2
1247258 | Água fria doméstica 2
1247270 | Água fria doméstica 2
1247283 | Água fria doméstica 2
1247761 | Água fria doméstica 2
1247771 | Água fria doméstica 2
1247825 | Água fria doméstica 2
1248132 | Água fria doméstica 2
1248151 | Água fria doméstica 2
1248163 | Água fria doméstica 2
1248481 | Água fria doméstica 2
1248588 | Água fria doméstica 3
1248759 | Água fria doméstica 2
1248777 | Água fria doméstica 2
1249043 | Água fria doméstica 1
1250189 | Água fria doméstica 3
1250212 | Água fria doméstica 3
1252056 | Água fria doméstica 3
1252058 | Água fria doméstica 3
1252060 | Água fria doméstica 3

# IfcFlowFitting: Joelho 90 com Bucha de Latao - Agua Fria_Soldavel - MEP - Tigre:Standard (20)
In: Nível 1
Type - Material: PVC Azul (2)
Type - Pset_DistributionFlowElementCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Standard
Material: PVC Azul; Group: Água fria doméstica 2
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Joelho 90 com Bucha de Latao - Agua Fria_Soldavel - MEP - Tigre:Standard:...)
1244021
1244403
1244556
1244625
1244844
1245198
1245230
1245260
1245268
1245276
1245621
1245687
1246046
1246155
1246586
1247062
1247293
1247388
1247839
1248173

# IfcFlowFitting: Te com Bucha de Latao - Agua Fria_Soldavel - MEP - Tigre:Standard (19)
In: Nível 1
Type - Material: PVC Azul
Type - Pset_DistributionFlowElementCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Standard
Pset_DistributionFlowElementCommon - sets with these values: 2
Group: Água fria doméstica 2
Name (Te com Bucha de Latao - Agua Fria_Soldavel - MEP - Tigre:Standard:...)
1244068
1244089
1244108
1244420
1244439
1245202
1245208
1245214
1245234
1245240
1246086
1246159
1246614
1246633
1247328
1247860
1247881
1247900
1248190

# IfcFlowFitting: Te_Reducao - Agua Fria_Soldavel - MEP - Tigre:Standard (18)
In: Nível 1
Type - Material: PVC Marrom
Type - Pset_DistributionFlowElementCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Standard
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Te_Reducao - Agua Fria_Soldavel - MEP - Tigre:Standard:...) | Group
1243949 | Água fria doméstica 2
1244347 | Água fria doméstica 2
1244615 | Água fria doméstica 2
1244797 | Água fria doméstica 2
1245182 | Água fria doméstica 2
1245218 | Água fria doméstica 2
1245264 | Água fria doméstica 2
1245270 | Água fria doméstica 2
1245496 | Água fria doméstica 2
1245660 | Água fria doméstica 2
1245911 | Água fria doméstica 2
1246886 | Água fria doméstica 2
1246990 | Água fria doméstica 2
1247110 | Água fria doméstica 2
1247376 | Água fria doméstica 2
1248105 | Água fria doméstica 2
1248755 | Água fria doméstica 2
1249037 | Água fria doméstica 1

# IfcFlowSegment: Tipos de tubos:PVC - Agua Fria - Tubo Soldável Tigre (159)
In: Nível 1
Type - Pset_DistributionFlowElementCommon - Reference: PVC - Agua Fria - Tubo Soldável Tigre
Type - Pset_QuantityTakeOff - Reference: PVC - Agua Fria - Tubo Soldável Tigre
Pset_DistributionFlowElementCommon - sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Tipos de tubos:PVC - Agua Fria - Tubo Soldável Tigre:...) | Length (m) | Group
1243901 | 0.252508 | Água fria doméstica 2
1243939 | 0.6551 | Água fria doméstica 2
1243950 | 0.636892 | Água fria doméstica 2
1243985 | 0.3687 | Água fria doméstica 2
1243993 | 2.1692 | Água fria doméstica 2
1244005 | 1.0757 | Água fria doméstica 2
1244060 | 0.0041 | Água fria doméstica 2
1244069 | 1.04326 | Água fria doméstica 2
1244081 | 0.0041 | Água fria doméstica 2
1244090 | 0.913563 | Água fria doméstica 2
1244100 | 0.0041 | Água fria doméstica 2
1244109 | 0.443376 | Água fria doméstica 2
1244348 | 1.16853 | Água fria doméstica 2
1244379 | 1.8701 | Água fria doméstica 2
1244387 | 0.665807 | Água fria doméstica 2
1244395 | 0.0147 | Água fria doméstica 2
1244412 | 0.0141 | Água fria doméstica 2
1244421 | 0.645087 | Água fria doméstica 2
1244431 | 0.0141 | Água fria doméstica 2
1244440 | 0.352806 | Água fria doméstica 2
1244493 | 1.7492 | Água fria doméstica 2
1244515 | 1.16903 | Água fria doméstica 2
1244522 | 0.2692 | Água fria doméstica 2
1244540 | 0.163684 | Água fria doméstica 2
1244612 | 0.1702 | Água fria doméstica 2
1244616 | 0.333816 | Água fria doméstica 2
1244798 | 0.3687 | Água fria doméstica 2
1244830 | 1.28086 | Água fria doméstica 2
1244924 | 1.16903 | Água fria doméstica 2
1245058 | 1.16853 | Água fria doméstica 2
1245176 | 0.252508 | Água fria doméstica 2
1245180 | 0.6601 | Água fria doméstica 2
1245183 | 0.446269 | Água fria doméstica 2
1245186 | 0.3687 | Água fria doméstica 2
1245190 | 2.1692 | Água fria doméstica 2
1245194 | 1.0757 | Água fria doméstica 2
1245200 | 0.0041 | Água fria doméstica 2
1245203 | 1.04326 | Água fria doméstica 2
1245206 | 0.0041 | Água fria doméstica 2
1245209 | 0.913563 | Água fria doméstica 2
1245212 | 0.0041 | Água fria doméstica 2
1245215 | 0.448376 | Água fria doméstica 2
1245219 | 1.16853 | Água fria doméstica 2
1245222 | 1.8701 | Água fria doméstica 2
1245224 | 0.665807 | Água fria doméstica 2
1245228 | 0.0147 | Água fria doméstica 2
1245232 | 0.0141 | Água fria doméstica 2
1245235 | 0.645087 | Água fria doméstica 2
1245238 | 0.0141 | Água fria doméstica 2
1245241 | 0.357806 | Água fria doméstica 2
1245244 | 1.7492 | Água fria doméstica 2
1245248 | 1.16903 | Água fria doméstica 2
1245252 | 0.2692 | Água fria doméstica 2
1245256 | 0.163684 | Água fria doméstica 2
1245262 | 0.1702 | Água fria doméstica 2
1245265 | 0.333816 | Água fria doméstica 2
1245271 | 0.3687 | Água fria doméstica 2
1245274 | 1.28086 | Água fria doméstica 2
1245279 | 1.16903 | Água fria doméstica 2
1245282 | 1.16853 | Água fria doméstica 2
1245348 | 1.7401 | Água fria doméstica 2
1245376 | 0.2141 | Água fria doméstica 2
1245422 | 2.79254 | Água fria doméstica 2
1245490 | 0.7101 | Água fria doméstica 2
1245497 | 0.158822 | Água fria doméstica 2
1245596 | 1.16903 | Água fria doméstica 2
1245603 | 0.5488 | Água fria doméstica 2
1245671 | 0.4647 | Água fria doméstica 2
1245789 | 1.16993 | Água fria doméstica 2
1245827 | 6.57 | Água fria doméstica 2
1245835 | 0.5509 | Água fria doméstica 2
1245881 | 0.7471 | Água fria doméstica 2
1245995 | 1.56903 | Água fria doméstica 2
1246002 | 1.2092 | Água fria doméstica 2
1246014 | 0.635545 | Água fria doméstica 2
1246033 | 0.3693 | Água fria doméstica 2
1246078 | 0.0141 | Água fria doméstica 2
1246087 | 0.323981 | Água fria doméstica 2
1246139 | 1.56903 | Água fria doméstica 2
1246143 | 1.2092 | Água fria doméstica 2
1246147 | 0.635545 | Água fria doméstica 2
1246151 | 0.3693 | Água fria doméstica 2
1246157 | 0.0141 | Água fria doméstica 2
1246160 | 0.323981 | Água fria doméstica 2
1246174 | 0.1687 | Água fria doméstica 2
1246189 | 0.4787 | Água fria doméstica 2
1246286 | 1.16903 | Água fria doméstica 2
1246410 | 1.16903 | Água fria doméstica 2
1246504 | 5.0394 | Água fria doméstica 2
1246514 | 6.7915 | Água fria doméstica 2
1246522 | 0.1612 | Água fria doméstica 2
1246545 | 0.3092 | Água fria doméstica 2
1246561 | 1.16903 | Água fria doméstica 2
1246568 | 0.37668 | Água fria doméstica 2
1246615 | 0.385596 | Água fria doméstica 2
1246625 | 0.0041 | Água fria doméstica 2
1246634 | 0.321424 | Água fria doméstica 2
1246778 | 1.16903 | Água fria doméstica 2
1246898 | 0.2709 | Água fria doméstica 2
1246916 | 3.9418 | Água fria doméstica 2
1246923 | 9.8618 | Água fria doméstica 2
1246947 | 3.9418 | Água fria doméstica 2
1246954 | 0.657809 | Água fria doméstica 2
1246966 | 0.979258 | Água fria doméstica 2
1246984 | 0.2315 | Água fria doméstica 2
1246991 | 0.189433 | Água fria doméstica 2
1247012 | 0.9612 | Água fria doméstica 2
1247037 | 1.46903 | Água fria doméstica 2
1247044 | 0.403021 | Água fria doméstica 2
1247056 | 0.0147 | Água fria doméstica 2
1247104 | 0.1115 | Água fria doméstica 2
1247111 | 1.06312 | Água fria doméstica 2
1247137 | 1.0812 | Água fria doméstica 2
1247194 | 0.769034 | Água fria doméstica 2
1247201 | 0.366097 | Água fria doméstica 2
1247255 | 0.7692 | Água fria doméstica 2
1247262 | 0.865597 | Água fria doméstica 2
1247280 | 0.3693 | Água fria doméstica 2
1247287 | 0.0147 | Água fria doméstica 2
1247320 | 0.0091 | Água fria doméstica 2
1247329 | 0.250803 | Água fria doméstica 2
1247373 | 1.06779 | Água fria doméstica 2
1247377 | 0.231303 | Água fria doméstica 2
1247380 | 0.0197 | Água fria doméstica 2
1247486 | 1.16903 | Água fria doméstica 2
1247594 | 1.16903 | Água fria doméstica 2
1247680 | 0.0685854 | Água fria doméstica 2
1247753 | 2.5418 | Água fria doméstica 2
1247763 | 0.4709 | Água fria doméstica 2
1247798 | 1.72594 | Água fria doméstica 2
1247812 | 1.16993 | Água fria doméstica 2
1247819 | 0.400314 | Água fria doméstica 2
1247861 | 0.363011 | Água fria doméstica 2
1247882 | 0.360199 | Água fria doméstica 2
1247901 | 0.327376 | Água fria doméstica 2
1248016 | 1.16903 | Água fria doméstica 2
1248116 | 4.6646 | Água fria doméstica 2
1248126 | 0.1692 | Água fria doméstica 2
1248148 | 1.16903 | Água fria doméstica 2
1248155 | 0.996337 | Água fria doméstica 2
1248191 | 0.360163 | Água fria doméstica 2
1248308 | 1.16903 | Água fria doméstica 2
1248464 | 0.1309 | Água fria doméstica 2
1248473 | 2.0168 | Água fria doméstica 2
1248568 | 0.2605 | Água fria doméstica 3
1248577 | 5.94163 | Água fria doméstica 3
1248747 | 1.52318 | Água fria doméstica 2
1248756 | 1.2169 | Água fria doméstica 2
1248962 | 0.2565 | Água fria doméstica 1
1249021 | 0.6475 | Água fria doméstica 1
1249038 | 0.2577 | Água fria doméstica 1
1249051 | 0.9287 | Água fria doméstica 1
1250185 | 0.0995171 | Água fria doméstica 3
1250187 | 0.0774896 | Água fria doméstica 3
1250200 | 0.0546016 | Água fria doméstica 3
1250205 | 0.0554896 | Água fria doméstica 3
1250210 | 0.0706908 | Água fria doméstica 3
1252035 | 0.347908 | Água fria doméstica 3
1252054 | 29.891 | Água fria doméstica 3

# IfcFlowTerminal: Assento para Bacia Sanitária:Assento para Bacia Sanitária (20)
In: Nível 1
Type - Classification: D2010110 Water Closets - Single (Uniformat); Material: Deca GE17 Branco Gelo Plástico
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deca
Type - Pset_QuantityTakeOff - Reference: Assento para Bacia Sanitária
Pset_DistributionFlowElementCommon - Reference: Assento para Bacia Sanitária; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Name (Assento para Bacia Sanitária:Assento para Bacia Sanitária:...)
1220912
1220916
1220919
1220922
1220928
1220931
1233205
1233208
1233211
1233214
1233217
1233220
1233223
1233226
1233229
1233232
1238623
1238628
1238636
1238640

# IfcFlowTerminal: Bacia para Caixa Acoplada:P.750_Creme CR37_Acionamento Simples 6lpf (20)
In: Nível 1
Type - Classification: D2010110 Water Closets - Single (Uniformat); Material: Deca CR37 Creme Cerâmica (2)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deca
Type - Pset_QuantityTakeOff - Reference: P.750_Creme CR37_Acionamento Simples 6lpf
Material: Deca CR37 Creme Cerâmica
Pset_DistributionFlowElementCommon - Reference: P.750_Creme CR37_Acionamento Simples 6lpf; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Name (Bacia para Caixa Acoplada:P.750_Creme CR37_Acionamento Simples 6lpf:...)
1220911
1220915
1220918
1220921
1220924
1220930
1233204
1233207
1233210
1233213
1233216
1233219
1233222
1233225
1233228
1233231
1238622
1238627
1238635
1238639

# IfcFlowTerminal: Caixa D_Agua_Completa_Com_Saida_Vertical- Agua Fria - MEP -Tigre:Caixa com Tampa - 1500 L, Caixa D_Agua_Completa_Com_Saida_Vertical- Agua Fria - MEP -Tigre:Caixa com Tampa - 1500 L:1243530
In: Nível 1
Type - Material: PEMD Azul (2), PVC Marrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Caixa com Tampa - 1500 L
Material: PEMD Azul; Group: Água fria doméstica 2; Água fria doméstica 1; Água fria doméstica 3
Pset_DistributionFlowElementCommon - Reference: Caixa com Tampa - 1500 L; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: Caixa de Descarga Acoplada:Caixa de Descarga Acoplada (20)
In: Nível 1
Type - Classification: D2010110 Water Closets - Single (Uniformat); Material: Deca CR37 Creme Cerâmica
Type - Pset_ManufacturerTypeInformation - Manufacturer: CD.00.17
Type - Pset_QuantityTakeOff - Reference: Caixa de Descarga Acoplada
Pset_DistributionFlowElementCommon - Reference: Caixa de Descarga Acoplada; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Name (Caixa de Descarga Acoplada:Caixa de Descarga Acoplada:...)
1220913
1220917
1220920
1220923
1220929
1220932
1233206
1233209
1233212
1233215
1233218
1233221
1233224
1233227
1233230
1233233
1238624
1238629
1238637
1238641

# IfcFlowTerminal: Chuveiro:1994.C.CT_Cromado CR10 (2)
In: Nível 1
Type - Classification: D2020 Domestic Water Distribution (Uniformat); Material: Deca CR10 Cromado Metal
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deca
Type - Pset_QuantityTakeOff - Reference: 1994.C.CT_Cromado CR10
Pset_DistributionFlowElementCommon - Reference: 1994.C.CT_Cromado CR10; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Name (Chuveiro:1994.C.CT_Cromado CR10:...)
1238621
1238626

# IfcFlowTerminal: Cuba Oval de Embutir1:L.37.17_Branco Gelo GE17 (15)
In: Nível 1
Type - Classification: D2010400 Sinks (Uniformat); Material: Deca GE17 Branco Gelo Cerâmica
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deca
Type - Pset_QuantityTakeOff - Reference: L.37.17_Branco Gelo GE17
Pset_DistributionFlowElementCommon - Reference: L.37.17_Branco Gelo GE17
Name (Cuba Oval de Embutir1:L.37.17_Branco Gelo GE17:...) | Pset_DistributionFlowElementCommon, sets with these values | Pset_ManufacturerTypeInformation, sets with these values
1211605 | 2
1211606 | 3 | 2
1211607 | 3 | 2
1212723 | 3 | 2
1212724 | 3 | 2
1212726 | 3 | 2
1236532 | 3 | 2
1236533 | 3 | 2
1236534 | 3 | 2
1236535 | 3 | 2
1236536 | 3 | 2
1236537 | 3 | 2
1238625 | 3 | 2
1238634 | 3 | 2
1238638 | 3 | 2

# IfcFlowTerminal: Cuba_Cozinha1:Cuba 40x70 (2)
In: Nível 1
Type - Material: Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: CABRO
Type - Pset_QuantityTakeOff - Reference: Cuba 40x70
Pset_DistributionFlowElementCommon - Reference: Cuba 40x70; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Name (Cuba_Cozinha1:Cuba 40x70:...)
1237559
1237560

# IfcFlowTerminal: Deca_Shared_Coluna para Tanque_TQ.03:CT.25_Branco Gelo GE17, Deca_Shared_Coluna para Tanque_TQ.03:CT.25_Branco Gelo GE17:1240619
In: Nível 1
Type - Classification: D2010400 Sinks (Uniformat); Material: Deca GE17 Branco Gelo Cerâmica
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deca
Type - Pset_QuantityTakeOff - Reference: CT.25_Branco Gelo GE17
Pset_DistributionFlowElementCommon - Reference: CT.25_Branco Gelo GE17; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: Deca_Tanque_TQ.03_40 Litros:TQ.03_Branco Gelo GE17, Deca_Tanque_TQ.03_40 Litros:TQ.03_Branco Gelo GE17:1240618
In: Nível 1
Type - Classification: D2010400 Sinks (Uniformat); Material: Deca GE17 Branco Gelo Cerâmica (2)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deca
Type - Pset_QuantityTakeOff - Reference: TQ.03_Branco Gelo GE17
Material: Deca GE17 Branco Gelo Cerâmica
Pset_DistributionFlowElementCommon - Reference: TQ.03_Branco Gelo GE17; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: FDE_BR03_ConjuntoLavatórioeBaciaAcessíveis:BR03_ConjuntoLavatórioeBaciaAcessíveis_ComVálvulaDeDescarga_DN32mm(1 1/4") (2)
In: Nível 1
Type - Classification: 08.16.091 (Uniformat); Material: FDE_AçoCromado, FDE_CerâmicaEsmaltadaBranca, FDE_ResinaPosliéster (Branco), FDE_AçoInox
Type - Pset_QuantityTakeOff - Reference: BR03_ConjuntoLavatórioeBaciaAcessíveis_ComVálvulaDeDescarga_DN32mm(1 1/4")
Pset_DistributionFlowElementCommon - Reference: BR03_ConjuntoLavatórioeBaciaAcessíveis_ComVálvulaDeDescarga_DN32mm(1 1/4"); sets with these values: 3
Name (FDE_BR03_ConjuntoLavatórioeBaciaAcessíveis:BR03_ConjuntoLavatórioeBaciaAcessíveis_ComVálvulaDeDescarga_DN32mm(1 1/4"):...)
1233198
1233201

# IfcFlowTerminal: FDE_H613_DispositivosRestritoresDeVazão:H613_RestritorDeVazãoPara6L/minTorneiraseMisturadores (2)
In: Nível 1
Type - Classification: 08.17.078 (Uniformat)
Type - Pset_QuantityTakeOff - Reference: H613_RestritorDeVazãoPara6L/minTorneiraseMisturadores
Pset_DistributionFlowElementCommon - Reference: H613_RestritorDeVazãoPara6L/minTorneiraseMisturadores; sets with these values: 3
Name (FDE_H613_DispositivosRestritoresDeVazão:H613_RestritorDeVazãoPara6L/minTorneiraseMisturadores:...)
1233199
1233203

# IfcFlowTerminal: NBS_FrankeSissonsLtd_DrnkngFntnPckgs_DrinkingFountain_ANMX309:ANMX309 (10)
In: Nível 1
Type - PredefinedType: SANITARYFOUNTAIN; Material: Aço inoxidável, escovado (2)
Type - Pset_DistributionFlowElementCommon - Reference: ANMX309
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: Drinking Fountain_ANMX309; Manufacturer: ws-info.uk@franke.com
Type - Pset_ProductRequirements - Name: DrinkingFountainPackages_DrinkingFountain_ANMX309_FrankeSissonsLtd; Category: n/a
Type - Pset_QuantityTakeOff - Reference: ANMX309
Material: Aço inoxidável, escovado
Pset_DistributionFlowElementCommon - sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: 7612979006131; SerialNumber: n/a
Name (NBS_FrankeSissonsLtd_DrnkngFntnPckgs_DrinkingFountain_ANMX309:ANMX309:...)
1243413
1243414
1243415
1243416
1243417
1243418
1243419
1243420
1243421
1243422

# IfcFlowTerminal: Pia de parede:455 x 360 x 850mm (5)
In: Nível 1
Type - Material: <Unnamed> (2)
Type - Pset_QuantityTakeOff - Reference: 455 x 360 x 850mm
Pset_DistributionFlowElementCommon - Reference: 455 x 360 x 850mm; sets with these values: 3
Name (Pia de parede:455 x 360 x 850mm:...)
1236523
1236528
1238630
1243423
1243427

# IfcFlowTerminal: Sifao para lavatorio - DocolBasicos1:Lavatório Top 2 (6)
In: Nível 1
Type - Material: Cromado - Docol
Type - Pset_ManufacturerTypeInformation - Manufacturer: Docol
Type - Pset_QuantityTakeOff - Reference: Lavatório Top 2
Pset_DistributionFlowElementCommon - Reference: Lavatório Top 2; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Name (Sifao para lavatorio - DocolBasicos1:Lavatório Top 2:...)
1212720
1212721
1212722
1212727
1212728
1212730

# IfcFlowTerminal: Tampa Caixa D_Agua - Agua Fria - MEP -Tigre:Tampa - 1500 L, Tampa Caixa D_Agua - Agua Fria - MEP -Tigre:Tampa - 1500 L:1243535
In: Nível 1
Type - Material: PEMD Azul
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Tampa - 1500 L
Pset_DistributionFlowElementCommon - Reference: Tampa - 1500 L; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: Torneira 1:Torneira 1 (10)
In: Nível 1
Type - Material: <Unnamed>
Type - Pset_QuantityTakeOff - Reference: Torneira 1
Pset_DistributionFlowElementCommon - Reference: Torneira 1; sets with these values: 3
Name (Torneira 1:Torneira 1:...)
1236524
1236525
1236529
1236530
1238631
1238632
1243424
1243425
1243428
1243429

# IfcFlowTerminal: Torneira 3:Torneira 3 (5)
In: Nível 1
Type - Material: <Unnamed>
Type - Pset_QuantityTakeOff - Reference: Torneira 3
Pset_DistributionFlowElementCommon - Reference: Torneira 3; sets with these values: 3
Name (Torneira 3:Torneira 3:...)
1236526
1236531
1238633
1243426
1243430

# IfcFlowTerminal: Torneira Boia - Agua Fria - MEP -Tigre:1/2", Torneira Boia - Agua Fria - MEP -Tigre:1/2":1243531
In: Nível 1
Type - Material: PEMD Azul
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: 1/2"
Material: PEMD Azul, Plastic
Pset_DistributionFlowElementCommon - Reference: 1/2"; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
