Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-06-16T12:52:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.11.27 - Exporter 21.1.11.27 - IU alternativa 21.1.11.27
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 16 12:52:28 2021 * Host: LAPTOP-D06TDN94 * Database: C:\Users\PAULAT~1\AppData\Local\Temp\4635c08b-ae0a-4f26-9cb2-6a9597644325\172ef3a7-fa38-40c6-ba9c-a5d8baf46309\ifc * Database version: 5507 * Database creation date: Wed Jun 16 12:52:03 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 16 12:52:04 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 16 12:52:04 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 m

# IfcBuilding, C.L. MONSENHOR ANTÔNIO SAMPAIO
LongName: C.L. MONSENHOR ANTÔNIO SAMPAIO
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Nível:8 mm Extremidade superior, Nível 1
In: C.L. MONSENHOR ANTÔNIO SAMPAIO
LongName: Nível 1; Elevation: 1.2 m

# IfcDistributionPort (1060)
Description: Flow
Name | FlowDirection | Group
Port_1211533 | SINK
Port_1211534 | SINK
Port_1211535 | SINK
Port_1212648 | SINK
InPort_1240981 | SINK | Sanitário 1
OutPort_1212649 | SOURCE | Sanitário 1
Port_1212650 | SINK
Port_1212651 | SINK
Port_1212652 | SINK
Port_1212654 | SINK
Port_1212655 | SINK
Port_1212656 | SINK
Port_1212658 | SINK
Port_1220839 | SOURCE
Port_1220839 | SINK
Port_1220843 | SINK
Port_1220843 | SOURCE
Port_1220846 | SINK
Port_1220846 | SOURCE
Port_1220849 | SOURCE
InPort_1243459 | SINK | Sanitário 8
OutPort_1220849 | SOURCE | Sanitário 8
Port_1220852 | SOURCE
InPort_1243412 | SINK | Sanitário 2
OutPort_1220852 | SOURCE | Sanitário 2
Port_1220858 | SOURCE
InPort_1243360 | SINK | Sanitário 2
OutPort_1220858 | SOURCE | Sanitário 2
4 x Port_1233126 | SOURCE
3 x Port_1233126 | SINK
4 x Port_1233129 | SOURCE
InPort_1242366 | SINK | Sanitário 3
OutPort_1233129 | SOURCE | Sanitário 3
Port_1233129 | SINK
InPort_1242717 | SINK | Sanitário 2
OutPort_1233129 | SOURCE | Sanitário 2
Port_1233132 | SOURCE
Port_1233132 | SINK
Port_1233135 | SINK
Port_1233135 | SOURCE
Port_1233138 | SOURCE
Port_1233138 | SINK
Port_1233141 | SOURCE
InPort_1243473 | SINK | Sanitário 2
OutPort_1233141 | SOURCE | Sanitário 2
Port_1233144 | SOURCE
InPort_1243398 | SINK | Sanitário 7
OutPort_1233144 | SOURCE | Sanitário 7
InPort_1243346 | SINK | Sanitário 6
OutPort_1233147 | SOURCE | Sanitário 6
Port_1233147 | SOURCE
Port_1233150 | SOURCE
Port_1233150 | SINK
InPort_1243511 | SINK | Sanitário 2
OutPort_1233153 | SOURCE | Sanitário 2
Port_1233153 | SOURCE
Port_1233156 | SOURCE
Port_1233156 | SINK
Port_1238549 | SOURCE
Port_1238550 | SOURCE
InPort_1248033 | SINK | Sanitário 16
OutPort_1238550 | SOURCE | Sanitário 16
Port_1238553 | SINK
Port_1238554 | SOURCE
InPort_1248019 | SINK | Sanitário 17
OutPort_1238555 | SOURCE | Sanitário 17
Port_1238555 | SOURCE
Port_1238562 | SINK
Port_1238563 | SINK
Port_1238563 | SOURCE
Port_1238566 | SINK
Port_1238567 | SOURCE
InPort_1247064 | SINK | Sanitário 12
OutPort_1238567 | SOURCE | Sanitário 12
Port_1240546 | SINK
InPort_1241025 | SINK | Sanitário 1
OutPort_1240981 | SOURCE | Sanitário 1
InPort_1241037 | SINK | Sanitário 1
OutPort_1241025 | SOURCE | Sanitário 1
InPort_1241050 | SINK | Sanitário 1
OutPort_1241037 | SOURCE | Sanitário 1
InPort_1241040 | SINK | Sanitário 1
OutPort_1241050 | SOURCE | Sanitário 1
InPort_1241244 | SINK | Sanitário 1
OutPort_1241040 | SOURCE | Sanitário 1
Port_1241144 | SOURCEANDSINK | Sanitário 1
InPort_1241144 | SOURCEANDSINK | Sanitário 1
OutPort_1241146 | SOURCEANDSINK | Sanitário 1
InPort_1241146 | SOURCEANDSINK | Sanitário 1
2 x OutPort_1241297 | SOURCEANDSINK | Sanitário 1
Port_1241162 | SOURCEANDSINK | Sanitário 1
InPort_1241162 | SOURCEANDSINK | Sanitário 1
OutPort_1241164 | SOURCEANDSINK | Sanitário 1
InPort_1241164 | SOURCEANDSINK | Sanitário 1
2 x OutPort_1241234 | SOURCEANDSINK | Sanitário 1
2 x InPort_1241216 | SOURCEANDSINK | Sanitário 1
OutPort_1241228 | SOURCEANDSINK | Sanitário 1
InPort_1243685 | SINK | Sanitário 1
OutPort_1241228 | SOURCE | Sanitário 1
InPort_1241228 | SOURCEANDSINK | Sanitário 1
OutPort_1241229 | SOURCEANDSINK | Sanitário 1
InPort_1241229 | SOURCEANDSINK | Sanitário 1
OutPort_1241244 | SOURCEANDSINK | Sanitário 1
InPort_1241244 | SOURCEANDSINK | Sanitário 1
OutPort_1241255 | SOURCEANDSINK | Sanitário 1
InPort_1241255 | SOURCEANDSINK | Sanitário 1
2 x OutPort_1241293 | SOURCEANDSINK | Sanitário 1
2 x InPort_1241285 | SOURCEANDSINK | Sanitário 1
5 x Port_1241310 | SOURCE
InPort_1241310 | SINK | Sanitário 14
OutPort_1257567 | SOURCE | Sanitário 14
Port_1241310 | SOURCE | Sanitário 1
InPort_1243221 | SINK | Sanitário 2
OutPort_1241310 | SOURCE | Sanitário 2
InPort_1241310 | SINK | Sanitário 1
OutPort_1243685 | SOURCE | Sanitário 1
InPort_1242392 | SINK | Sanitário 3
OutPort_1242366 | SOURCE | Sanitário 3
InPort_1242433 | SINK | Sanitário 3
OutPort_1242389 | SOURCE | Sanitário 3
InPort_1242389 | SINK | Sanitário 3
OutPort_1242392 | SOURCE | Sanitário 3
InPort_1242559 | SINK | Sanitário 3
OutPort_1242433 | SOURCE | Sanitário 3
7 x Port_1242468 | SOURCE
InPort_1242468 | SINK | Sanitário 3
OutPort_1242559 | SOURCE | Sanitário 3
InPort_1243194 | SINK | Sanitário 2
OutPort_1242468 | SOURCE | Sanitário 2
InPort_1243078 | SINK | Sanitário 2
OutPort_1242717 | SOURCE | Sanitário 2
InPort_1243202 | SINK | Sanitário 2
OutPort_1243070 | SOURCE | Sanitário 2
InPort_1243070 | SINK | Sanitário 2
OutPort_1243078 | SOURCE | Sanitário 2
2 x Port_1243080 | SOURCEANDSINK
2 x InPort_1243231 | SINK | Sanitário 2
OutPort_1243194 | SOURCE | Sanitário 2
2 x InPort_1243202 | SOURCEANDSINK | Sanitário 2
2 x OutPort_1254754 | SOURCEANDSINK | Sanitário 2
OutPort_1243203 | SOURCEANDSINK | Sanitário 2
InPort_1243203 | SOURCEANDSINK | Sanitário 2
2 x OutPort_1243258 | SOURCEANDSINK | Sanitário 2
2 x Port_1243208 | SOURCEANDSINK
OutPort_1243221 | SOURCE | Sanitário 2
InPort_1243232 | SINK | Sanitário 2
OutPort_1243231 | SOURCE | Sanitário 2
InPort_1254753 | SINK | Sanitário 2
OutPort_1243232 | SOURCE | Sanitário 2
2 x Port_1243237 | SOURCEANDSINK
2 x InPort_1243250 | SOURCEANDSINK | Sanitário 2
2 x OutPort_1243270 | SOURCEANDSINK | Sanitário 2
2 x Port_1243262 | SOURCEANDSINK
2 x InPort_1243264 | SOURCEANDSINK | Sanitário 2
2 x OutPort_1243298 | SOURCEANDSINK | Sanitário 2
2 x Port_1243272 | SOURCEANDSINK
2 x InPort_1243274 | SOURCEANDSINK | Sanitário 2
2 x OutPort_1254109 | SOURCEANDSINK | Sanitário 2
InPort_1243298 | SINK | Sanitário 2
OutPort_1243550 | SOURCE | Sanitário 2
2 x Port_1243302 | SOURCEANDSINK
Port_1243346 | SINK | Sanitário 6
InPort_1243378 | SINK | Sanitário 2
OutPort_1243350 | SOURCE | Sanitário 2
InPort_1243350 | SINK | Sanitário 2
OutPort_1243362 | SOURCE | Sanitário 2
InPort_1243362 | SINK | Sanitário 2
OutPort_1243360 | SOURCE | Sanitário 2
2 x Port_1243364 | SOURCEANDSINK
InPort_1243368 | SINK | Sanitário 2
OutPort_1243378 | SOURCE | Sanitário 2
2 x InPort_1243420 | SINK | Sanitário 2
OutPort_1243368 | SOURCE | Sanitário 2
2 x Port_1243380 | SOURCEANDSINK
Port_1243398 | SINK | Sanitário 7
InPort_1243402 | SINK | Sanitário 2
OutPort_1243428 | SOURCE | Sanitário 2
OutPort_1243402 | SOURCE | Sanitário 2
InPort_1243428 | SINK | Sanitário 2
OutPort_1243412 | SOURCE | Sanitário 2
InPort_1243421 | SINK | Sanitário 2
OutPort_1243420 | SOURCE | Sanitário 2
2 x InPort_1243481 | SINK | Sanitário 2
OutPort_1243421 | SOURCE | Sanitário 2
2 x Port_1243424 | SOURCEANDSINK
2 x Port_1243430 | SOURCEANDSINK
Port_1243459 | SINK | Sanitário 8
OutPort_1243463 | SOURCE | Sanitário 2
InPort_1243463 | SINK | Sanitário 2
OutPort_1243489 | SOURCE | Sanitário 2
InPort_1243489 | SINK | Sanitário 2
OutPort_1243473 | SOURCE | Sanitário 2
InPort_1243482 | SINK | Sanitário 2
OutPort_1243481 | SOURCE | Sanitário 2
2 x InPort_1243549 | SINK | Sanitário 2
OutPort_1243482 | SOURCE | Sanitário 2
2 x Port_1243485 | SOURCEANDSINK
2 x Port_1243491 | SOURCEANDSINK
InPort_1243557 | SINK | Sanitário 2
OutPort_1243511 | SOURCE | Sanitário 2
InPort_1243535 | SINK | Sanitário 2
OutPort_1243557 | SOURCE | Sanitário 2
OutPort_1243535 | SOURCE | Sanitário 2
InPort_1243550 | SINK | Sanitário 2
OutPort_1243549 | SOURCE | Sanitário 2
2 x Port_1243553 | SOURCEANDSINK
2 x Port_1243559 | SOURCEANDSINK
InPort_1243871 | SOURCEANDSINK | Sanitário 4
OutPort_1243873 | SOURCEANDSINK | Sanitário 4
Port_1243871 | SOURCEANDSINK | Sanitário 4
InPort_1243873 | SOURCEANDSINK | Sanitário 4
OutPort_1243875 | SOURCEANDSINK | Sanitário 4
InPort_1243875 | SOURCEANDSINK | Sanitário 4
2 x OutPort_1243879 | SOURCEANDSINK | Sanitário 4
2 x InPort_1243877 | SOURCEANDSINK | Sanitário 4
2 x OutPort_1243897 | SOURCEANDSINK | Sanitário 4
Port_1243881 | SOURCEANDSINK | Sanitário 4
InPort_1243881 | SOURCEANDSINK | Sanitário 4
OutPort_1243883 | SOURCEANDSINK | Sanitário 4
InPort_1243883 | SOURCEANDSINK | Sanitário 4
2 x OutPort_1243905 | SOURCEANDSINK | Sanitário 4
Port_1243885 | SOURCEANDSINK | Sanitário 4
InPort_1243885 | SOURCEANDSINK | Sanitário 4
OutPort_1243887 | SOURCEANDSINK | Sanitário 4
InPort_1243887 | SOURCEANDSINK | Sanitário 4
2 x OutPort_1243895 | SOURCEANDSINK | Sanitário 4
2 x InPort_1243889 | SOURCEANDSINK | Sanitário 4
OutPort_1243891 | SOURCEANDSINK | Sanitário 4
InPort_1244856 | SINK | Sanitário 4
OutPort_1243891 | SOURCE | Sanitário 4
InPort_1243891 | SOURCEANDSINK | Sanitário 4
OutPort_1243892 | SOURCEANDSINK | Sanitário 4
InPort_1243892 | SOURCEANDSINK | Sanitário 4
InPort_1243897 | SOURCEANDSINK | Sanitário 4
OutPort_1243899 | SOURCEANDSINK | Sanitário 4
InPort_1243899 | SOURCEANDSINK | Sanitário 4
2 x OutPort_1243903 | SOURCEANDSINK | Sanitário 4
2 x InPort_1243901 | SOURCEANDSINK | Sanitário 4
InPort_1243911 | SINK | Sanitário 10
OutPort_1243907 | SOURCE | Sanitário 10
Port_1243907 | SOURCE | Sanitário 10
InPort_1243909 | SINK | Sanitário 10
OutPort_1243911 | SOURCE | Sanitário 10
InPort_1243913 | SINK | Sanitário 10
OutPort_1243909 | SOURCE | Sanitário 10
InPort_1244477 | SINK | Sanitário 10
OutPort_1243913 | SOURCE | Sanitário 10
InPort_1243917 | SOURCEANDSINK | Sanitário 5
2 x OutPort_1243921 | SOURCEANDSINK | Sanitário 5
Port_1243917 | SOURCEANDSINK | Sanitário 5
2 x InPort_1243919 | SOURCEANDSINK | Sanitário 5
OutPort_1243927 | SOURCEANDSINK | Sanitário 5
2 x Port_1243923 | SOURCEANDSINK
2 x InPort_1243927 | SOURCEANDSINK | Sanitário 5
OutPort_1243928 | SOURCEANDSINK | Sanitário 5
OutPort_1244784 | SOURCEANDSINK | Sanitário 5
InPort_1243928 | SOURCEANDSINK | Sanitário 5
2 x OutPort_1243943 | SOURCEANDSINK | Sanitário 5
2 x Port_1243931 | SOURCEANDSINK
2 x InPort_1245501 | SINK | Sanitário 5
OutPort_1243933 | SOURCE | Sanitário 5
InPort_1243933 | SINK | Sanitário 5
OutPort_1244126 | SOURCE | Sanitário 5
2 x InPort_1243941 | SOURCEANDSINK | Sanitário 5
2 x OutPort_1243949 | SOURCEANDSINK | Sanitário 5
2 x Port_1243945 | SOURCEANDSINK
2 x InPort_1243947 | SOURCEANDSINK | Sanitário 5
OutPort_1243955 | SOURCEANDSINK | Sanitário 5
2 x Port_1243951 | SOURCEANDSINK
2 x InPort_1243955 | SOURCEANDSINK | Sanitário 5
2 x OutPort_1244006 | SOURCEANDSINK | Sanitário 5
OutPort_1254082 | SOURCEANDSINK | Sanitário 5
2 x Port_1243957 | SOURCEANDSINK
2 x InPort_1243959 | SOURCEANDSINK | Sanitário 5
2 x OutPort_1243969 | SOURCEANDSINK | Sanitário 5
2 x OutPort_1243963 | SOURCEANDSINK | Sanitário 5
Port_1243961 | SOURCEANDSINK | Sanitário 5
InPort_1243961 | SOURCEANDSINK | Sanitário 5
2 x Port_1243965 | SOURCEANDSINK
2 x InPort_1243967 | SOURCEANDSINK | Sanitário 5
2 x OutPort_1243977 | SOURCEANDSINK | Sanitário 5
2 x Port_1243971 | SOURCEANDSINK
2 x InPort_1243973 | SOURCEANDSINK | Sanitário 5
2 x OutPort_1243983 | SOURCEANDSINK | Sanitário 5
Port_1243975 | SOURCEANDSINK | Sanitário 5
InPort_1243975 | SOURCEANDSINK | Sanitário 5
InPort_1243977 | SOURCEANDSINK | Sanitário 5
OutPort_1243978 | SOURCEANDSINK | Sanitário 5
InPort_1243978 | SOURCEANDSINK | Sanitário 5
2 x OutPort_1243991 | SOURCEANDSINK | Sanitário 5
2 x Port_1243981 | SOURCEANDSINK
2 x Port_1243985 | SOURCEANDSINK
2 x InPort_1243987 | SOURCEANDSINK | Sanitário 5
2 x OutPort_1243997 | SOURCEANDSINK | Sanitário 5
Port_1243989 | SOURCEANDSINK | Sanitário 5
InPort_1243989 | SOURCEANDSINK | Sanitário 5
InPort_1243991 | SOURCEANDSINK | Sanitário 5
OutPort_1243992 | SOURCEANDSINK | Sanitário 5
InPort_1243992 | SOURCEANDSINK | Sanitário 5
2 x OutPort_1244005 | SOURCEANDSINK | Sanitário 5
2 x Port_1243995 | SOURCEANDSINK
2 x Port_1243999 | SOURCEANDSINK
InPort_1244001 | SOURCEANDSINK | Sanitário 5
2 x OutPort_1244011 | SOURCEANDSINK | Sanitário 5
Port_1244001 | SOURCEANDSINK | Sanitário 5
2 x InPort_1244003 | SOURCEANDSINK | Sanitário 5
InPort_1244005 | SOURCEANDSINK | Sanitário 5
2 x Port_1244009 | SOURCEANDSINK
2 x Port_1244013 | SOURCEANDSINK
7 x Port_1244086 | SOURCE
InPort_1245502 | SINK | Sanitário 5
OutPort_1244086 | SOURCE | Sanitário 5
InPort_1244086 | SINK | Sanitário 10
OutPort_1244477 | SOURCE | Sanitário 10
InPort_1244126 | SINK | Sanitário 4
OutPort_1244856 | SOURCE | Sanitário 4
7 x Port_1244126 | SOURCE
InPort_1244784 | SOURCEANDSINK | Sanitário 5
OutPort_1254655 | SOURCEANDSINK | Sanitário 5
OutPort_1245502 | SOURCE | Sanitário 5
InPort_1254656 | SINK | Sanitário 5
OutPort_1245501 | SOURCE | Sanitário 5
2 x Port_1245507 | SOURCEANDSINK
Port_1245700 | SOURCE | Sanitário 9
InPort_1245719 | SINK | Sanitário 9
OutPort_1245700 | SOURCE | Sanitário 9
InPort_1246690 | SINK | Sanitário 9
OutPort_1245716 | SOURCE | Sanitário 9
InPort_1245716 | SINK | Sanitário 9
OutPort_1245719 | SOURCE | Sanitário 9
InPort_1245748 | SINK | Sanitário 9
OutPort_1246690 | SOURCE | Sanitário 9
InPort_1246517 | SINK | Sanitário 9
OutPort_1245748 | SOURCE | Sanitário 9
InPort_1246907 | SINK | Sanitário 12
OutPort_1246517 | SOURCE | Sanitário 12
7 x Port_1246517 | SOURCE
InPort_1246810 | SINK | Sanitário 12
OutPort_1246915 | SOURCE | Sanitário 12
InPort_1247211 | SINK | Sanitário 12
OutPort_1246810 | SOURCE | Sanitário 12
2 x InPort_1254435 | SINK | Sanitário 12
OutPort_1246907 | SOURCE | Sanitário 12
2 x InPort_1246915 | SINK | Sanitário 12
OutPort_1247132 | SOURCE | Sanitário 12
OutPort_1254436 | SOURCE | Sanitário 12
2 x Port_1246919 | SOURCEANDSINK
InPort_1247085 | SINK | Sanitário 12
OutPort_1247064 | SOURCE | Sanitário 12
InPort_1247140 | SINK | Sanitário 12
OutPort_1247085 | SOURCE | Sanitário 12
2 x Port_1247087 | SOURCEANDSINK
InPort_1247132 | SINK | Sanitário 12
OutPort_1247152 | SOURCE | Sanitário 12
InPort_1247152 | SINK | Sanitário 12
OutPort_1247140 | SOURCE | Sanitário 12
2 x Port_1247154 | SOURCEANDSINK
Port_1247157 | SOURCE | Sanitário 13
InPort_1247161 | SINK | Sanitário 13
OutPort_1247157 | SOURCE | Sanitário 13
InPort_1247167 | SINK | Sanitário 13
OutPort_1247159 | SOURCE | Sanitário 13
InPort_1247159 | SINK | Sanitário 13
OutPort_1247161 | SOURCE | Sanitário 13
InPort_1247165 | SINK | Sanitário 13
OutPort_1247163 | SOURCE | Sanitário 13
InPort_1247163 | SINK | Sanitário 13
OutPort_1247167 | SOURCE | Sanitário 13
7 x Port_1247165 | SOURCE
InPort_1247171 | SINK | Sanitário 12
OutPort_1247165 | SOURCE | Sanitário 12
2 x InPort_1247169 | SOURCEANDSINK | Sanitário 12
OutPort_1247173 | SOURCEANDSINK | Sanitário 12
2 x OutPort_1254002 | SOURCEANDSINK | Sanitário 12
InPort_1254501 | SINK | Sanitário 12
OutPort_1247171 | SOURCE | Sanitário 12
InPort_1247173 | SOURCEANDSINK | Sanitário 12
OutPort_1247183 | SOURCEANDSINK | Sanitário 12
InPort_1247173 | SINK | Sanitário 12
OutPort_1254502 | SOURCE | Sanitário 12
2 x Port_1247175 | SOURCEANDSINK
Port_1247177 | SOURCEANDSINK | Sanitário 12
InPort_1247177 | SOURCEANDSINK | Sanitário 12
OutPort_1247179 | SOURCEANDSINK | Sanitário 12
InPort_1247179 | SOURCEANDSINK | Sanitário 12
OutPort_1247185 | SOURCEANDSINK | Sanitário 12
2 x Port_1247181 | SOURCEANDSINK
InPort_1247183 | SOURCEANDSINK | Sanitário 12
2 x OutPort_1247187 | SOURCEANDSINK | Sanitário 12
InPort_1247185 | SOURCEANDSINK | Sanitário 12
2 x Port_1247189 | SOURCEANDSINK
InPort_1247203 | SINK | Sanitário 12
OutPort_1247211 | SOURCE | Sanitário 12
InPort_1247221 | SINK | Sanitário 12
OutPort_1247203 | SOURCE | Sanitário 12
InPort_1253997 | SINK | Sanitário 12
OutPort_1247221 | SOURCE | Sanitário 12
2 x Port_1247338 | SOURCEANDSINK
2 x Port_1247358 | SOURCEANDSINK
2 x InPort_1247555 | SOURCEANDSINK | Sanitário 11
2 x OutPort_1247668 | SOURCEANDSINK | Sanitário 11
OutPort_1247558 | SOURCEANDSINK | Sanitário 11
Port_1247558 | SOURCEANDSINK | Sanitário 11
2 x InPort_1247613 | SOURCEANDSINK | Sanitário 11
OutPort_1247615 | SOURCEANDSINK | Sanitário 11
2 x OutPort_1247619 | SOURCEANDSINK | Sanitário 11
Port_1247615 | SOURCEANDSINK | Sanitário 11
2 x InPort_1247617 | SOURCEANDSINK | Sanitário 11
OutPort_1247639 | SOURCEANDSINK | Sanitário 11
InPort_1247639 | SOURCEANDSINK | Sanitário 11
2 x OutPort_1247665 | SOURCEANDSINK | Sanitário 11
2 x InPort_1247656 | SOURCEANDSINK | Sanitário 11
OutPort_1247664 | SOURCEANDSINK | Sanitário 11
InPort_1247664 | SOURCEANDSINK | Sanitário 11
InPort_1247890 | SINK | Sanitário 11
OutPort_1247664 | SOURCE | Sanitário 11
7 x Port_1247770 | SOURCE
InPort_1254878 | SINK | Sanitário 15
OutPort_1247770 | SOURCE | Sanitário 15
InPort_1247770 | SINK | Sanitário 11
OutPort_1247890 | SOURCE | Sanitário 11
Port_1248019 | SINK | Sanitário 17
InPort_1248051 | SINK | Sanitário 16
OutPort_1248023 | SOURCE | Sanitário 16
InPort_1248023 | SINK | Sanitário 16
OutPort_1248035 | SOURCE | Sanitário 16
InPort_1248035 | SINK | Sanitário 16
OutPort_1248033 | SOURCE | Sanitário 16
2 x Port_1248037 | SOURCEANDSINK
InPort_1249219 | SINK | Sanitário 16
OutPort_1248051 | SOURCE | Sanitário 16
2 x Port_1248053 | SOURCEANDSINK
Port_1248075 | SOURCE | Sanitário 18
InPort_1248095 | SINK | Sanitário 18
OutPort_1248075 | SOURCE | Sanitário 18
InPort_1248092 | SINK | Sanitário 18
OutPort_1248095 | SOURCE | Sanitário 18
InPort_1248107 | SINK | Sanitário 18
OutPort_1248092 | SOURCE | Sanitário 18
InPort_1248223 | SINK | Sanitário 18
OutPort_1248107 | SOURCE | Sanitário 18
7 x Port_1248175 | SOURCE
InPort_1248693 | SINK | Sanitário 16
OutPort_1248175 | SOURCE | Sanitário 16
InPort_1248175 | SINK | Sanitário 18
OutPort_1248223 | SOURCE | Sanitário 18
2 x InPort_1248304 | SOURCEANDSINK | Sanitário 16
2 x OutPort_1249228 | SOURCEANDSINK | Sanitário 16
OutPort_1255334 | SOURCEANDSINK | Sanitário 16
8 x Port_1248579 | SOURCE
InPort_1248684 | SINK | Sanitário 16
OutPort_1248579 | SOURCE | Sanitário 16
2 x InPort_1248692 | SINK | Sanitário 16
OutPort_1248684 | SOURCE | Sanitário 16
InPort_1248986 | SINK | Sanitário 16
OutPort_1248692 | SOURCE | Sanitário 16
OutPort_1248693 | SOURCE | Sanitário 16
2 x Port_1248696 | SOURCEANDSINK
InPort_1248710 | SINK | Sanitário 20
OutPort_1248712 | SOURCE | Sanitário 20
InPort_1248861 | SINK | Sanitário 20
OutPort_1248710 | SOURCE | Sanitário 20
Port_1248712 | SOURCE | Sanitário 20
7 x Port_1248773 | SOURCE
InPort_1248773 | SINK | Sanitário 20
OutPort_1248853 | SOURCE | Sanitário 20
InPort_1248977 | SINK | Sanitário 16
OutPort_1248773 | SOURCE | Sanitário 16
InPort_1248853 | SINK | Sanitário 20
OutPort_1248861 | SOURCE | Sanitário 20
2 x InPort_1248985 | SINK | Sanitário 16
OutPort_1248977 | SOURCE | Sanitário 16
OutPort_1248986 | SOURCE | Sanitário 16
InPort_1255335 | SINK | Sanitário 16
OutPort_1248985 | SOURCE | Sanitário 16
2 x Port_1248989 | SOURCEANDSINK
2 x InPort_1249204 | SOURCEANDSINK | Sanitário 16
OutPort_1249218 | SOURCEANDSINK | Sanitário 16
InPort_1249218 | SINK | Sanitário 16
OutPort_1249219 | SOURCE | Sanitário 16
InPort_1249218 | SOURCEANDSINK | Sanitário 16
OutPort_1255388 | SOURCEANDSINK | Sanitário 16
2 x Port_1249222 | SOURCEANDSINK
2 x Port_1249230 | SOURCEANDSINK
Port_1253966 | SOURCEANDSINK | Sanitário 12
InPort_1253966 | SOURCEANDSINK | Sanitário 12
2 x OutPort_1253996 | SOURCEANDSINK | Sanitário 12
2 x InPort_1253988 | SOURCEANDSINK | Sanitário 12
InPort_1253996 | SINK | Sanitário 12
OutPort_1253997 | SOURCE | Sanitário 12
2 x Port_1254000 | SOURCEANDSINK
2 x Port_1254004 | SOURCEANDSINK
Port_1254082 | SOURCEANDSINK | Sanitário 5
2 x InPort_1254101 | SOURCEANDSINK | Sanitário 2
2 x OutPort_1254125 | SOURCEANDSINK | Sanitário 2
2 x Port_1254111 | SOURCEANDSINK
InPort_1254113 | SOURCEANDSINK | Sanitário 2
Port_1254113 | SOURCEANDSINK | Sanitário 2
2 x Port_1254127 | SOURCEANDSINK
2 x Port_1254229 | SOURCEANDSINK | Sanitário 19
2 x Port_1254275 | SOURCEANDSINK | Sanitário 21
2 x Port_1254294 | SOURCEANDSINK | Sanitário 22
2 x Port_1254310 | SOURCEANDSINK | Sanitário 23
InPort_1254457 | SINK | Ventilação 2
OutPort_1254419 | SOURCE | Ventilação 2
OutPort_1254419 | SOURCE | Sanitário 12
InPort_1254436 | SINK | Sanitário 12
OutPort_1254435 | SOURCE | Sanitário 12
InPort_1254447 | SINK | Ventilação 2
OutPort_1254457 | SOURCE | Ventilação 2
InPort_1254479 | SINK | Ventilação 2
OutPort_1254447 | SOURCE | Ventilação 2
2 x Port_1254459 | SOURCEANDSINK
InPort_1254476 | SINK | Ventilação 2
OutPort_1254479 | SOURCE | Ventilação 2
Port_1254476 | SINK | Ventilação 2
2 x Port_1254481 | SOURCEANDSINK
InPort_1254519 | SINK | Ventilação 3
OutPort_1254498 | SOURCE | Ventilação 3
InPort_1254498 | SINK | Ventilação 3
OutPort_1254501 | SOURCE | Ventilação 3
InPort_1254502 | SINK | Sanitário 12
OutPort_1254501 | SOURCE | Sanitário 12
InPort_1254544 | SINK | Ventilação 3
OutPort_1254511 | SOURCE | Ventilação 3
InPort_1254511 | SINK | Ventilação 3
OutPort_1254519 | SOURCE | Ventilação 3
2 x Port_1254521 | SOURCEANDSINK
InPort_1254541 | SINK | Ventilação 3
OutPort_1254544 | SOURCE | Ventilação 3
Port_1254541 | SINK | Ventilação 3
2 x Port_1254546 | SOURCEANDSINK
2 x Port_1254572 | SOURCEANDSINK
2 x Port_1254606 | SOURCEANDSINK
InPort_1254675 | SINK | Ventilação 4
OutPort_1254652 | SOURCE | Ventilação 4
InPort_1254652 | SINK | Ventilação 4
OutPort_1254655 | SOURCE | Ventilação 4
InPort_1254655 | SINK | Sanitário 5
OutPort_1254656 | SOURCE | Sanitário 5
InPort_1254697 | SINK | Ventilação 4
OutPort_1254667 | SOURCE | Ventilação 4
InPort_1254667 | SINK | Ventilação 4
OutPort_1254675 | SOURCE | Ventilação 4
2 x Port_1254677 | SOURCEANDSINK
InPort_1254694 | SINK | Ventilação 4
OutPort_1254697 | SOURCE | Ventilação 4
Port_1254694 | SINK | Ventilação 4
2 x Port_1254699 | SOURCEANDSINK
2 x Port_1254721 | SOURCEANDSINK
InPort_1254750 | SINK | Ventilação 5
OutPort_1254753 | SOURCE | Ventilação 5
InPort_1254773 | SINK | Ventilação 5
OutPort_1254750 | SOURCE | Ventilação 5
InPort_1254753 | SOURCEANDSINK | Sanitário 2
InPort_1254798 | SINK | Ventilação 5
OutPort_1254765 | SOURCE | Ventilação 5
InPort_1254765 | SINK | Ventilação 5
OutPort_1254773 | SOURCE | Ventilação 5
2 x Port_1254775 | SOURCEANDSINK
InPort_1254795 | SINK | Ventilação 5
OutPort_1254798 | SOURCE | Ventilação 5
Port_1254795 | SINK | Ventilação 5
2 x Port_1254800 | SOURCEANDSINK
2 x Port_1254822 | SOURCEANDSINK
InPort_1254874 | SINK | Ventilação 6
OutPort_1254877 | SOURCE | Ventilação 6
InPort_1254895 | SINK | Ventilação 6
OutPort_1254874 | SOURCE | Ventilação 6
InPort_1255214 | SINK | Sanitário 15
OutPort_1254877 | SOURCE | Sanitário 15
InPort_1254877 | SINK | Sanitário 15
OutPort_1254878 | SOURCE | Sanitário 15
InPort_1254889 | SINK | Ventilação 6
OutPort_1254895 | SOURCE | Ventilação 6
InPort_1254924 | SINK | Ventilação 6
OutPort_1254889 | SOURCE | Ventilação 6
2 x Port_1254897 | SOURCEANDSINK
InPort_1254921 | SINK | Ventilação 6
OutPort_1254924 | SOURCE | Ventilação 6
Port_1254921 | SINK | Ventilação 6
2 x Port_1254926 | SOURCEANDSINK
2 x Port_1254956 | SOURCEANDSINK
2 x Port_1254981 | SOURCE
InPort_1254981 | SINK | Sanitário 15
OutPort_1255214 | SOURCE | Sanitário 15
InPort_1255301 | SINK | Sanitário 24
OutPort_1254981 | SOURCE | Sanitário 24
2 x Port_1254982 | SOURCE
Port_1254982 | SINK
Port_1255301 | SINK | Sanitário 24
InPort_1255331 | SINK | Ventilação 7
OutPort_1255334 | SOURCE | Ventilação 7
InPort_1255352 | SINK | Ventilação 7
OutPort_1255331 | SOURCE | Ventilação 7
InPort_1255334 | SINK | Sanitário 16
OutPort_1255335 | SOURCE | Sanitário 16
2 x Port_1255338 | SOURCEANDSINK
InPort_1255344 | SINK | Ventilação 7
OutPort_1255352 | SOURCE | Ventilação 7
InPort_1255369 | SINK | Ventilação 7
OutPort_1255344 | SOURCE | Ventilação 7
2 x Port_1255354 | SOURCEANDSINK
Port_1255366 | SINK | Ventilação 7
InPort_1255366 | SINK | Ventilação 7
OutPort_1255369 | SOURCE | Ventilação 7
2 x Port_1255371 | SOURCEANDSINK
Port_1255388 | SOURCEANDSINK | Sanitário 16
7 x Port_1256642 | SOURCE
InPort_1260197 | SINK | Sanitário 32
OutPort_1256642 | SOURCE | Sanitário 32
InPort_1256642 | SINK | Sanitário 30
OutPort_1259232 | SOURCE | Sanitário 30
7 x Port_1256692 | SOURCE
InPort_1260091 | SINK | Sanitário 33
OutPort_1256692 | SOURCE | Sanitário 33
InPort_1256692 | SINK | Sanitário 34
OutPort_1259730 | SOURCE | Sanitário 34
Port_1256722 | SINK | Sanitário 25
Port_1256730 | SINK
Port_1256738 | SINK
2 x InPort_1257420 | SOURCEANDSINK | Sanitário 14
OutPort_1257430 | SOURCEANDSINK | Sanitário 14
OutPort_1257422 | SOURCEANDSINK | Sanitário 14
2 x InPort_1257422 | SOURCEANDSINK | Sanitário 14
OutPort_1257423 | SOURCEANDSINK | Sanitário 14
OutPort_1257479 | SOURCEANDSINK | Sanitário 14
InPort_1257423 | SOURCEANDSINK | Sanitário 14
2 x OutPort_1257452 | SOURCEANDSINK | Sanitário 14
Port_1257430 | SOURCEANDSINK | Sanitário 14
2 x InPort_1257450 | SOURCEANDSINK | Sanitário 14
OutPort_1257456 | SOURCEANDSINK | Sanitário 14
InPort_1257608 | SINK | Sanitário 14
OutPort_1257452 | SOURCE | Sanitário 14
Port_1257456 | SOURCEANDSINK | Sanitário 14
2 x InPort_1257476 | SOURCEANDSINK | Sanitário 14
2 x OutPort_1257504 | SOURCEANDSINK | Sanitário 14
OutPort_1257484 | SOURCEANDSINK | Sanitário 14
InPort_1257479 | SOURCEANDSINK | Sanitário 14
Port_1257484 | SOURCEANDSINK | Sanitário 14
InPort_1257567 | SINK | Sanitário 14
OutPort_1257618 | SOURCE | Sanitário 14
InPort_1257618 | SINK | Sanitário 14
OutPort_1257608 | SOURCE | Sanitário 14
2 x InPort_1257949 | SOURCEANDSINK | Sanitário 26
OutPort_1257951 | SOURCEANDSINK | Sanitário 26
OutPort_1257955 | SOURCEANDSINK | Sanitário 26
2 x InPort_1257951 | SOURCEANDSINK | Sanitário 26
OutPort_1257965 | SOURCEANDSINK | Sanitário 26
OutPort_1257952 | SOURCEANDSINK | Sanitário 26
InPort_1257952 | SOURCEANDSINK | Sanitário 26
2 x OutPort_1257959 | SOURCEANDSINK | Sanitário 26
Port_1257955 | SOURCEANDSINK | Sanitário 26
2 x InPort_1257957 | SOURCEANDSINK | Sanitário 26
OutPort_1257961 | SOURCEANDSINK | Sanitário 26
InPort_1257971 | SINK | Sanitário 26
OutPort_1257959 | SOURCE | Sanitário 26
Port_1257961 | SOURCEANDSINK | Sanitário 26
2 x InPort_1257963 | SOURCEANDSINK | Sanitário 26
2 x OutPort_1257969 | SOURCEANDSINK | Sanitário 26
OutPort_1257967 | SOURCEANDSINK | Sanitário 26
InPort_1257965 | SOURCEANDSINK | Sanitário 26
Port_1257967 | SOURCEANDSINK | Sanitário 26
InPort_1258578 | SINK | Sanitário 26
OutPort_1257971 | SOURCE | Sanitário 26
7 x Port_1258400 | SOURCE
InPort_1258400 | SINK | Sanitário 26
OutPort_1258570 | SOURCE | Sanitário 26
InPort_1260299 | SINK | Sanitário 27
OutPort_1258400 | SOURCE | Sanitário 27
InPort_1258570 | SINK | Sanitário 26
OutPort_1258578 | SOURCE | Sanitário 26
InPort_1258599 | SINK | Sanitário 27
OutPort_1260298 | SOURCE | Sanitário 27
Port_1258599 | SINK | Sanitário 27
2 x Port_1258675 | SOURCEANDSINK | Sanitário 28
2 x Port_1258706 | SOURCEANDSINK | Sanitário 29
2 x InPort_1258776 | SOURCEANDSINK | Sanitário 30
OutPort_1258778 | SOURCEANDSINK | Sanitário 30
OutPort_1258782 | SOURCEANDSINK | Sanitário 30
2 x InPort_1258778 | SOURCEANDSINK | Sanitário 30
OutPort_1258779 | SOURCEANDSINK | Sanitário 30
OutPort_1258792 | SOURCEANDSINK | Sanitário 30
InPort_1258779 | SOURCEANDSINK | Sanitário 30
2 x OutPort_1258786 | SOURCEANDSINK | Sanitário 30
Port_1258782 | SOURCEANDSINK | Sanitário 30
2 x InPort_1258784 | SOURCEANDSINK | Sanitário 30
OutPort_1258788 | SOURCEANDSINK | Sanitário 30
InPort_1258786 | SOURCEANDSINK | Sanitário 30
2 x OutPort_1258875 | SOURCEANDSINK | Sanitário 30
Port_1258788 | SOURCEANDSINK | Sanitário 30
2 x InPort_1258790 | SOURCEANDSINK | Sanitário 30
OutPort_1258794 | SOURCEANDSINK | Sanitário 30
2 x OutPort_1258796 | SOURCEANDSINK | Sanitário 30
InPort_1258792 | SOURCEANDSINK | Sanitário 30
Port_1258794 | SOURCEANDSINK | Sanitário 30
2 x InPort_1258867 | SOURCEANDSINK | Sanitário 30
OutPort_1258874 | SOURCEANDSINK | Sanitário 30
OutPort_1258886 | SOURCEANDSINK | Sanitário 30
InPort_1258874 | SOURCEANDSINK | Sanitário 30
InPort_1259130 | SINK | Sanitário 30
OutPort_1258874 | SOURCE | Sanitário 30
Port_1258886 | SOURCEANDSINK | Sanitário 30
InPort_1259148 | SINK | Sanitário 30
OutPort_1259130 | SOURCE | Sanitário 30
InPort_1259232 | SINK | Sanitário 30
OutPort_1259148 | SOURCE | Sanitário 30
2 x Port_1259292 | SOURCEANDSINK | Sanitário 31
Port_1259329 | SINK | Sanitário 32
InPort_1259329 | SINK | Sanitário 32
OutPort_1260196 | SOURCE | Sanitário 32
InPort_1259668 | SOURCEANDSINK | Sanitário 34
OutPort_1259714 | SOURCEANDSINK | Sanitário 34
Port_1259668 | SOURCEANDSINK | Sanitário 34
Port_1259711 | SOURCEANDSINK | Sanitário 34
InPort_1259711 | SOURCEANDSINK | Sanitário 34
2 x OutPort_1259726 | SOURCEANDSINK | Sanitário 34
InPort_1259714 | SOURCEANDSINK | Sanitário 34
2 x OutPort_1259727 | SOURCEANDSINK | Sanitário 34
2 x InPort_1259718 | SOURCEANDSINK | Sanitário 34
OutPort_1259738 | SOURCEANDSINK | Sanitário 34
InPort_1259726 | SOURCEANDSINK | Sanitário 34
InPort_1259730 | SINK | Sanitário 34
OutPort_1259755 | SOURCE | Sanitário 34
InPort_1259738 | SOURCEANDSINK | Sanitário 34
2 x OutPort_1259756 | SOURCEANDSINK | Sanitário 34
2 x InPort_1259747 | SOURCEANDSINK | Sanitário 34
2 x OutPort_1259779 | SOURCEANDSINK | Sanitário 34
OutPort_1259755 | SOURCEANDSINK | Sanitário 34
InPort_1259755 | SOURCEANDSINK | Sanitário 34
2 x InPort_1259776 | SOURCEANDSINK | Sanitário 34
OutPort_1259789 | SOURCEANDSINK | Sanitário 34
Port_1259789 | SOURCEANDSINK | Sanitário 34
InPort_1260009 | SINK | Sanitário 33
OutPort_1260090 | SOURCE | Sanitário 33
InPort_1260027 | SINK | Sanitário 33
OutPort_1260009 | SOURCE | Sanitário 33
InPort_1260039 | SINK | Sanitário 33
OutPort_1260015 | SOURCE | Sanitário 33
InPort_1260015 | SINK | Sanitário 33
OutPort_1260027 | SOURCE | Sanitário 33
2 x Port_1260031 | SOURCEANDSINK
InPort_1260033 | SINK | Sanitário 33
OutPort_1260039 | SOURCE | Sanitário 33
Port_1260033 | SINK | Sanitário 33
2 x Port_1260041 | SOURCEANDSINK
InPort_1260112 | SINK | Ventilação 8
OutPort_1260070 | SOURCE | Ventilação 8
InPort_1260070 | SINK | Ventilação 8
OutPort_1260090 | SOURCE | Ventilação 8
InPort_1260090 | SINK | Sanitário 33
OutPort_1260091 | SOURCE | Sanitário 33
InPort_1260100 | SINK | Ventilação 8
OutPort_1260112 | SOURCE | Ventilação 8
InPort_1260134 | SINK | Ventilação 8
OutPort_1260100 | SOURCE | Ventilação 8
2 x Port_1260114 | SOURCEANDSINK
Port_1260131 | SINK | Ventilação 8
InPort_1260131 | SINK | Ventilação 8
OutPort_1260134 | SOURCE | Ventilação 8
2 x Port_1260136 | SOURCEANDSINK
2 x Port_1260158 | SOURCEANDSINK
InPort_1260193 | SINK | Ventilação 9
OutPort_1260196 | SOURCE | Ventilação 9
InPort_1260214 | SINK | Ventilação 9
OutPort_1260193 | SOURCE | Ventilação 9
InPort_1260196 | SINK | Sanitário 32
OutPort_1260197 | SOURCE | Sanitário 32
InPort_1260244 | SINK | Ventilação 9
OutPort_1260206 | SOURCE | Ventilação 9
InPort_1260206 | SINK | Ventilação 9
OutPort_1260214 | SOURCE | Ventilação 9
2 x Port_1260216 | SOURCEANDSINK
InPort_1260241 | SINK | Ventilação 9
OutPort_1260244 | SOURCE | Ventilação 9
Port_1260241 | SINK | Ventilação 9
2 x Port_1260246 | SOURCEANDSINK
2 x Port_1260268 | SOURCEANDSINK
InPort_1260295 | SINK | Ventilação 10
OutPort_1260298 | SOURCE | Ventilação 10
InPort_1260316 | SINK | Ventilação 10
OutPort_1260295 | SOURCE | Ventilação 10
InPort_1260298 | SINK | Sanitário 27
OutPort_1260299 | SOURCE | Sanitário 27
InPort_1260308 | SINK | Ventilação 10
OutPort_1260316 | SOURCE | Ventilação 10
InPort_1260348 | SINK | Ventilação 10
OutPort_1260308 | SOURCE | Ventilação 10
2 x Port_1260318 | SOURCEANDSINK
Port_1260345 | SINK | Ventilação 10
InPort_1260345 | SINK | Ventilação 10
OutPort_1260348 | SOURCE | Ventilação 10
2 x Port_1260350 | SOURCEANDSINK
2 x Port_1260372 | SOURCEANDSINK

# IfcFlowFitting: Joelho 45_90 - Serie Normal - Esgoto - MEP - Tigre:Standard (99)
In: Nível 1
Type - Material: PVC Branco
Type - Pset_DistributionFlowElementCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Standard
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Joelho 45_90 - Serie Normal - Esgoto - MEP - Tigre:Standard:...) | Group
1241025 | Sanitário 1
1241050 | Sanitário 1
1241144 | Sanitário 1
1241162 | Sanitário 1
1241234 | Sanitário 1
1241293 | Sanitário 1
1241297 | Sanitário 1
1242392 | Sanitário 3
1242433 | Sanitário 3
1243078 | Sanitário 2
1243258 | Sanitário 2
1243270 | Sanitário 2
1243362 | Sanitário 2
1243378 | Sanitário 2
1243428 | Sanitário 2
1243489 | Sanitário 2
1243557 | Sanitário 2
1243873 | Sanitário 4
1243879 | Sanitário 4
1243881 | Sanitário 4
1243885 | Sanitário 4
1243895 | Sanitário 4
1243903 | Sanitário 4
1243905 | Sanitário 4
1243911 | Sanitário 10
1243913 | Sanitário 10
1243921 | Sanitário 5
1243943 | Sanitário 5
1243949 | Sanitário 5
1243963 | Sanitário 5
1243969 | Sanitário 5
1243983 | Sanitário 5
1243997 | Sanitário 5
1244011 | Sanitário 5
1245719 | Sanitário 9
1246690 | Sanitário 9
1247085 | Sanitário 12
1247152 | Sanitário 12
1247161 | Sanitário 13
1247167 | Sanitário 13
1247179 | Sanitário 12
1247187 | Sanitário 12
1247211 | Sanitário 12
1247221 | Sanitário 12
1247558 | Sanitário 11
1247615 | Sanitário 11
1247619 | Sanitário 11
1247639 | Sanitário 11
1247668 | Sanitário 11
1248035 | Sanitário 16
1248051 | Sanitário 16
1248095 | Sanitário 18
1248107 | Sanitário 18
1248712 | Sanitário 20
1248861 | Sanitário 20
1249228 | Sanitário 16
1254002 | Sanitário 12
1254109 | Sanitário 2
1254125 | Sanitário 2
1254457 | Ventilação 2
1254479 | Ventilação 2
1254519 | Ventilação 3
1254544 | Ventilação 3
1254675 | Ventilação 4
1254697 | Ventilação 4
1254773 | Ventilação 5
1254798 | Ventilação 5
1254895 | Ventilação 6
1254924 | Ventilação 6
1255352 | Ventilação 7
1255369 | Ventilação 7
1257430 | Sanitário 14
1257456 | Sanitário 14
1257484 | Sanitário 14
1257504 | Sanitário 14
1257618 | Sanitário 14
1257955 | Sanitário 26
1257961 | Sanitário 26
1257967 | Sanitário 26
1257969 | Sanitário 26
1258578 | Sanitário 26
1258782 | Sanitário 30
1258788 | Sanitário 30
1258794 | Sanitário 30
1258796 | Sanitário 30
1258886 | Sanitário 30
1259148 | Sanitário 30
1259714 | Sanitário 34
1259738 | Sanitário 34
1259779 | Sanitário 34
1259789 | Sanitário 34
1260027 | Sanitário 33
1260039 | Sanitário 33
1260112 | Ventilação 8
1260134 | Ventilação 8
1260214 | Ventilação 9
1260244 | Ventilação 9
1260316 | Ventilação 10
1260348 | Ventilação 10

# IfcFlowFitting: Juncao - Serie Normal - Esgoto - MEP - Tigre:Standard (33)
In: Nível 1
Type - Material: PVC Branco
Type - Pset_DistributionFlowElementCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Standard
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Juncao - Serie Normal - Esgoto - MEP - Tigre:Standard:...) | Group
1241228 | Sanitário 1
1241244 | Sanitário 1
1243202 | Sanitário 2
1243231 | Sanitário 2
1243298 | Sanitário 2
1243420 | Sanitário 2
1243481 | Sanitário 2
1243549 | Sanitário 2
1243891 | Sanitário 4
1243897 | Sanitário 4
1243927 | Sanitário 5
1243955 | Sanitário 5
1243977 | Sanitário 5
1243991 | Sanitário 5
1244005 | Sanitário 5
1245501 | Sanitário 5
1246915 | Sanitário 12
1247173 | Sanitário 12
1247664 | Sanitário 11
1248692 | Sanitário 16
1248985 | Sanitário 16
1249218 | Sanitário 16
1253996 | Sanitário 12
1255334 | Ventilação 7; Sanitário 16
1257422 | Sanitário 14
1257452 | Sanitário 14
1257951 | Sanitário 26
1257959 | Sanitário 26
1258778 | Sanitário 30
1258786 | Sanitário 30
1258874 | Sanitário 30
1259726 | Sanitário 34
1259755 | Sanitário 34

# IfcFlowFitting: Luva Simples para Conexão - Serie Normal - Esgoto - MEP - Tigre:Standard (75)
In: Nível 1
Type - Material: PVC Branco
Type - Pset_DistributionFlowElementCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Standard
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Luva Simples para Conexão - Serie Normal - Esgoto - MEP - Tigre:Standard:...)
1243080
1243208
1243237
1243262
1243272
1243302
1243364
1243380
1243424
1243430
1243485
1243491
1243553
1243559
1243923
1243931
1243945
1243951
1243957
1243965
1243971
1243981
1243985
1243995
1243999
1244009
1244013
1245507
1246919
1247087
1247154
1247175
1247181
1247189
1247338
1247358
1248037
1248053
1248696
1248989
1249222
1249230
1254000
1254004
1254111
1254127
1254459
1254481
1254521
1254546
1254572
1254606
1254677
1254699
1254721
1254775
1254800
1254822
1254897
1254926
1254956
1255338
1255354
1255371
1260031
1260041
1260114
1260136
1260158
1260216
1260246
1260268
1260318
1260350
1260372

# IfcFlowFitting: Te - Serie Normal - Esgoto - MEP - Tigre:Standard (8)
In: Nível 1
Type - Material: PVC Branco
Type - Pset_DistributionFlowElementCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Standard
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Te - Serie Normal - Esgoto - MEP - Tigre:Standard:...) | Group
1254435 | Sanitário 12
1254501 | Ventilação 3; Sanitário 12
1254655 | Ventilação 4; Sanitário 5
1254753 | Ventilação 5; Sanitário 2
1254877 | Ventilação 6; Sanitário 15
1260090 | Ventilação 8; Sanitário 33
1260196 | Ventilação 9; Sanitário 32
1260298 | Ventilação 10; Sanitário 27

# IfcFlowSegment: Tipos de tubos:PVC - Esgoto - Série Normal Tigre (169)
In: Nível 1
Type - Pset_DistributionFlowElementCommon - Reference: PVC - Esgoto - Série Normal Tigre
Type - Pset_QuantityTakeOff - Reference: PVC - Esgoto - Série Normal Tigre
Pset_DistributionFlowElementCommon - sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Tipos de tubos:PVC - Esgoto - Série Normal Tigre:...) | Length (m) | Group
1240981 | 0.0066 | Sanitário 1
1241037 | 0.8524 | Sanitário 1
1241040 | 0.0569157 | Sanitário 1
1241146 | 0.8524 | Sanitário 1
1241164 | 0.8524 | Sanitário 1
1241216 | 0.0569157 | Sanitário 1
1241229 | 0.635909 | Sanitário 1
1241255 | 0.616593 | Sanitário 1
1241285 | 0.0964172 | Sanitário 1
1242366 | 0.0362 | Sanitário 3
1242389 | 0.7024 | Sanitário 3
1242559 | 0.445497 | Sanitário 3
1242717 | 0.33345 | Sanitário 2
1243070 | 1.08526 | Sanitário 2
1243194 | 0.0860717 | Sanitário 2
1243203 | 0.337309 | Sanitário 2
1243221 | 1.81362 | Sanitário 2
1243232 | 0.110498 | Sanitário 2
1243250 | 0.742922 | Sanitário 2
1243264 | 0.644111 | Sanitário 2
1243274 | 0.250011 | Sanitário 2
1243346 | 0.39245 | Sanitário 6
1243350 | 0.119065 | Sanitário 2
1243360 | 0.33345 | Sanitário 2
1243368 | 0.791709 | Sanitário 2
1243398 | 0.39245 | Sanitário 7
1243402 | 0.0202542 | Sanitário 2
1243412 | 0.33345 | Sanitário 2
1243421 | 0.8612 | Sanitário 2
1243459 | 0.39245 | Sanitário 8
1243463 | 0.0202542 | Sanitário 2
1243473 | 0.33345 | Sanitário 2
1243482 | 0.8912 | Sanitário 2
1243511 | 0.33345 | Sanitário 2
1243535 | 0.0202542 | Sanitário 2
1243550 | 0.30279 | Sanitário 2
1243685 | 0.00852961 | Sanitário 1
1243871 | 0.00515108 | Sanitário 4
1243875 | 0.8524 | Sanitário 4
1243877 | 0.0569157 | Sanitário 4
1243883 | 0.8524 | Sanitário 4
1243887 | 0.8524 | Sanitário 4
1243889 | 0.0569157 | Sanitário 4
1243892 | 0.635909 | Sanitário 4
1243899 | 0.616593 | Sanitário 4
1243901 | 0.0964172 | Sanitário 4
1243907 | 0.0362 | Sanitário 10
1243909 | 0.7024 | Sanitário 10
1243917 | 0.33345 | Sanitário 5
1243919 | 1.08526 | Sanitário 5
1243928 | 0.337309 | Sanitário 5
1243933 | 1.82324 | Sanitário 5
1243941 | 0.742922 | Sanitário 5
1243947 | 0.644111 | Sanitário 5
1243959 | 0.119065 | Sanitário 5
1243961 | 0.33345 | Sanitário 5
1243967 | 0.791709 | Sanitário 5
1243973 | 0.0202542 | Sanitário 5
1243975 | 0.33345 | Sanitário 5
1243978 | 0.8612 | Sanitário 5
1243987 | 0.0202542 | Sanitário 5
1243989 | 0.33345 | Sanitário 5
1243992 | 0.8912 | Sanitário 5
1244001 | 0.33345 | Sanitário 5
1244003 | 0.0202542 | Sanitário 5
1244006 | 0.30279 | Sanitário 5
1244477 | 0.446379 | Sanitário 10
1244784 | 0.0902656 | Sanitário 5
1244856 | 0.034564 | Sanitário 4
1245502 | 0.127782 | Sanitário 5
1245700 | 0.0562 | Sanitário 9
1245716 | 0.8524 | Sanitário 9
1245748 | 0.170203 | Sanitário 9
1246810 | 0.228411 | Sanitário 12
1246907 | 0.075617 | Sanitário 12
1247064 | 0.33345 | Sanitário 12
1247132 | 0.893114 | Sanitário 12
1247140 | 0.31243 | Sanitário 12
1247157 | 0.0562 | Sanitário 13
1247159 | 0.8524 | Sanitário 13
1247163 | 0.170203 | Sanitário 13
1247169 | 0.151461 | Sanitário 12
1247171 | 0.107851 | Sanitário 12
1247177 | 0.33345 | Sanitário 12
1247183 | 0.893114 | Sanitário 12
1247185 | 0.31243 | Sanitário 12
1247203 | 0.0837187 | Sanitário 12
1247555 | 0.8524 | Sanitário 11
1247613 | 0.8524 | Sanitário 11
1247617 | 0.728341 | Sanitário 11
1247656 | 0.710101 | Sanitário 11
1247665 | 1.05905 | Sanitário 11
1247890 | 0.0487618 | Sanitário 11
1248019 | 0.39245 | Sanitário 17
1248023 | 0.211628 | Sanitário 16
1248033 | 0.61345 | Sanitário 16
1248075 | 0.0262 | Sanitário 18
1248092 | 1.1324 | Sanitário 18
1248223 | 0.424251 | Sanitário 18
1248304 | 0.121398 | Sanitário 16
1248684 | 0.148884 | Sanitário 16
1248693 | 1.52573 | Sanitário 16
1248710 | 1.1324 | Sanitário 20
1248853 | 0.0343762 | Sanitário 20
1248977 | 0.162956 | Sanitário 16
1248986 | 0.621171 | Sanitário 16
1249204 | 0.168313 | Sanitário 16
1249219 | 2.23247 | Sanitário 16
1253966 | 1.11224 | Sanitário 12
1253988 | 0.0937315 | Sanitário 12
1253997 | 1.84542 | Sanitário 12
1254082 | 0.39855 | Sanitário 5
1254101 | 0.112627 | Sanitário 2
1254113 | 0.591461 | Sanitário 2
1254229 | 3.76 | Sanitário 19
1254275 | 4.6738 | Sanitário 21
1254294 | 8.1 | Sanitário 22
1254310 | 5.74 | Sanitário 23
1254436 | 0.319333 | Sanitário 12
1254502 | 0.287099 | Sanitário 12
1254656 | 0.0902656 | Sanitário 5
1254754 | 0.110498 | Sanitário 2
1254878 | 1.99343 | Sanitário 15
1255214 | 2.91019 | Sanitário 15
1255301 | 4.8 | Sanitário 24
1255335 | 0.0560478 | Sanitário 16
1255388 | 0.853007 | Sanitário 16
1257420 | 0.8532 | Sanitário 14
1257423 | 0.347367 | Sanitário 14
1257450 | 0.8532 | Sanitário 14
1257476 | 0.8524 | Sanitário 14
1257479 | 0.334559 | Sanitário 14
1257567 | 0.188502 | Sanitário 14
1257608 | 0.107858 | Sanitário 14
1257949 | 0.8532 | Sanitário 26
1257952 | 0.347367 | Sanitário 26
1257957 | 0.8532 | Sanitário 26
1257963 | 0.8524 | Sanitário 26
1257965 | 0.334559 | Sanitário 26
1257971 | 0.513458 | Sanitário 26
1258570 | 0.454198 | Sanitário 26
1258599 | 0.306941 | Sanitário 27
1258675 | 7.9 | Sanitário 28
1258706 | 12.7 | Sanitário 29
1258776 | 0.8532 | Sanitário 30
1258779 | 0.347367 | Sanitário 30
1258784 | 0.8532 | Sanitário 30
1258790 | 0.8524 | Sanitário 30
1258792 | 0.354559 | Sanitário 30
1258867 | 0.8532 | Sanitário 30
1258875 | 0.344388 | Sanitário 30
1259130 | 0.238113 | Sanitário 30
1259232 | 0.130609 | Sanitário 30
1259292 | 7.5 | Sanitário 31
1259329 | 0.761072 | Sanitário 32
1259668 | 0.0362 | Sanitário 34
1259711 | 0.2818 | Sanitário 34
1259718 | 0.505502 | Sanitário 34
1259727 | 0.8532 | Sanitário 34
1259730 | 0.0396731 | Sanitário 34
1259747 | 0.4252 | Sanitário 34
1259756 | 0.909344 | Sanitário 34
1259776 | 0.8524 | Sanitário 34
1260009 | 0.220518 | Sanitário 33
1260015 | 2.05936 | Sanitário 33
1260033 | 2.36388 | Sanitário 33
1260091 | 0.123462 | Sanitário 33
1260197 | 2.08323 | Sanitário 32
1260299 | 0.0773594 | Sanitário 27

# IfcFlowSegment: Tipos de tubos:PVC - Ventilação - Série Normal Tigre (27)
In: Nível 1
Type - Pset_DistributionFlowElementCommon - Reference: PVC - Ventilação - Série Normal Tigre
Type - Pset_QuantityTakeOff - Reference: PVC - Ventilação - Série Normal Tigre
Pset_DistributionFlowElementCommon - sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Tipos de tubos:PVC - Ventilação - Série Normal Tigre:...) | Length (m) | Group
1254419 | 0.10582 | Sanitário 12; Ventilação 2
1254447 | 0.1526 | Ventilação 2
1254476 | 4.4688 | Ventilação 2
1254498 | 0.10582 | Ventilação 3
1254511 | 0.1776 | Ventilação 3
1254541 | 4.1688 | Ventilação 3
1254652 | 0.10582 | Ventilação 4
1254667 | 0.5576 | Ventilação 4
1254694 | 4.6688 | Ventilação 4
1254750 | 0.10582 | Ventilação 5
1254765 | 0.5776 | Ventilação 5
1254795 | 4.6688 | Ventilação 5
1254874 | 0.10582 | Ventilação 6
1254889 | 0.4176 | Ventilação 6
1254921 | 4.6688 | Ventilação 6
1255331 | 0.10582 | Ventilação 7
1255344 | 0.5176 | Ventilação 7
1255366 | 4.9488 | Ventilação 7
1260070 | 0.10582 | Ventilação 8
1260100 | 0.9976 | Ventilação 8
1260131 | 4.6688 | Ventilação 8
1260193 | 0.10582 | Ventilação 9
1260206 | 0.1376 | Ventilação 9
1260241 | 4.6688 | Ventilação 9
1260295 | 0.10582 | Ventilação 10
1260308 | 0.3776 | Ventilação 10
1260345 | 4.6688 | Ventilação 10

# IfcFlowTerminal: Assento para Bacia Sanitária:Assento para Bacia Sanitária (19)
In: Nível 1
Type - Classification: D2010110 Water Closets - Single (Uniformat); Material: Deca GE17 Branco Gelo Plástico
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deca
Type - Pset_QuantityTakeOff - Reference: Assento para Bacia Sanitária
Pset_DistributionFlowElementCommon - Reference: Assento para Bacia Sanitária; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Name (Assento para Bacia Sanitária:Assento para Bacia Sanitária:...)
1220840
1220844
1220847
1220850
1220856
1220859
1233133
1233136
1233139
1233142
1233145
1233148
1233151
1233154
1233157
1238551
1238556
1238564
1238568

# IfcFlowTerminal: Bacia para Caixa Acoplada:P.750_Creme CR37_Acionamento Simples 6lpf (19)
In: Nível 1
Type - Classification: D2010110 Water Closets - Single (Uniformat); Material: Deca CR37 Creme Cerâmica (2)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deca
Type - Pset_QuantityTakeOff - Reference: P.750_Creme CR37_Acionamento Simples 6lpf
Material: Deca CR37 Creme Cerâmica
Pset_DistributionFlowElementCommon - Reference: P.750_Creme CR37_Acionamento Simples 6lpf; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Name (Bacia para Caixa Acoplada:P.750_Creme CR37_Acionamento Simples 6lpf:...) | Group
1220839
1220843
1220846
1220849 | Sanitário 8
1220852 | Sanitário 2
1220858 | Sanitário 2
1233132
1233135
1233138
1233141 | Sanitário 2
1233144 | Sanitário 7
1233147 | Sanitário 6
1233150
1233153 | Sanitário 2
1233156
1238550 | Sanitário 16
1238555 | Sanitário 17
1238563
1238567 | Sanitário 12

# IfcFlowTerminal: Caixa Sifonada Girafacil Montada Completa - Caixas e Ralos - Esgoto - MEP - Tigre:Corpo - 150x170x75 (13)
In: Nível 1
Type - Material: Tigre - Caixas e Ralos_PVC Branco
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Corpo - 150x170x75
Pset_DistributionFlowElementCommon - Reference: Corpo - 150x170x75; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Name (Caixa Sifonada Girafacil Montada Completa - Caixas e Ralos - Esgoto - MEP - Tigre:Corpo - 150x170x75:...) | Group
1241310 | Sanitário 1; Sanitário 2; Sanitário 14
1242468 | Sanitário 2; Sanitário 3
1244086 | Sanitário 10; Sanitário 5
1244126 | Sanitário 4; Sanitário 5
1246517 | Sanitário 12; Sanitário 9
1247165 | Sanitário 12; Sanitário 13
1247770 | Sanitário 11; Sanitário 15
1248175 | Sanitário 16; Sanitário 18
1248579 | Sanitário 16
1248773 | Sanitário 16; Sanitário 20
1256642 | Sanitário 30; Sanitário 32
1256692 | Sanitário 34; Sanitário 33
1258400 | Sanitário 27; Sanitário 26

# IfcFlowTerminal: Caixa de Descarga Acoplada:Caixa de Descarga Acoplada (19)
In: Nível 1
Type - Classification: D2010110 Water Closets - Single (Uniformat); Material: Deca CR37 Creme Cerâmica
Type - Pset_ManufacturerTypeInformation - Manufacturer: CD.00.17
Type - Pset_QuantityTakeOff - Reference: Caixa de Descarga Acoplada
Pset_DistributionFlowElementCommon - Reference: Caixa de Descarga Acoplada; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Name (Caixa de Descarga Acoplada:Caixa de Descarga Acoplada:...)
1220841
1220845
1220848
1220851
1220857
1220860
1233134
1233137
1233140
1233143
1233146
1233149
1233152
1233155
1233158
1238552
1238557
1238565
1238569

# IfcFlowTerminal: Caixa de Gordura com Prolongador - Caixas de Gordura e Inspecao - Esgoto - MEP - Tigre:Com prolongador - Com entrada, Caixa de Gordura com Prolongador - Caixas de Gordura e Inspecao - Esgoto - MEP - Tigre:Com prolongador - Com entrada:1254981
In: Nível 1
Type - Material: Tigre - Cx Gordura_Corpo (2), Tigre - Cx Gordura_Tampa
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Com prolongador - Com entrada
Material: Tigre - Cx Gordura_Tampa, Tigre - Cx Gordura_Corpo; Group: Sanitário 24; Sanitário 15
Pset_DistributionFlowElementCommon - Reference: Com prolongador - Com entrada; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: Caixas no Piso:Caixa de Inspeção 60x60cm Em tijolo e Concreto (8)
In: Nível 1
Type - Material: Concreto, Tijolo, Comum, Brita, Ferro, fundido
Type - Pset_QuantityTakeOff - Reference: Caixa de Inspeção 60x60cm Em tijolo e Concreto
Material: Ferro, fundido, Concreto, Brita, Tijolo, Comum
Pset_DistributionFlowElementCommon - Reference: Caixa de Inspeção 60x60cm Em tijolo e Concreto; sets with these values: 3
Name (Caixas no Piso:Caixa de Inspeção 60x60cm Em tijolo e Concreto:...)
1253790
1254034
1254045
1254058
1254069
1258363
1258644
1259255

# IfcFlowTerminal: Chuveiro:1994.C.CT_Cromado CR10 (2)
In: Nível 1
Type - Classification: D2020 Domestic Water Distribution (Uniformat); Material: Deca CR10 Cromado Metal
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deca
Type - Pset_QuantityTakeOff - Reference: 1994.C.CT_Cromado CR10
Pset_DistributionFlowElementCommon - Reference: 1994.C.CT_Cromado CR10; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Name (Chuveiro:1994.C.CT_Cromado CR10:...)
1238549
1238554

# IfcFlowTerminal: Cuba Oval de Embutir1:L.37.17_Branco Gelo GE17 (9)
In: Nível 1
Type - Classification: D2010400 Sinks (Uniformat); Material: Deca GE17 Branco Gelo Cerâmica
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deca
Type - Pset_QuantityTakeOff - Reference: L.37.17_Branco Gelo GE17
Pset_DistributionFlowElementCommon - Reference: L.37.17_Branco Gelo GE17
Name (Cuba Oval de Embutir1:L.37.17_Branco Gelo GE17:...) | Pset_DistributionFlowElementCommon, sets with these values | Pset_ManufacturerTypeInformation, sets with these values
1211533 | 2
1211534 | 3 | 2
1211535 | 3 | 2
1212651 | 3 | 2
1212652 | 3 | 2
1212654 | 3 | 2
1238553 | 3 | 2
1238562 | 3 | 2
1238566 | 3 | 2

# IfcFlowTerminal: Cuba_Cozinha1:Cuba 40x70 (2)
In: Nível 1
Type - Material: Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: CABRO
Type - Pset_QuantityTakeOff - Reference: Cuba 40x70
Pset_DistributionFlowElementCommon - Reference: Cuba 40x70; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Name (Cuba_Cozinha1:Cuba 40x70:...)
1237487
1237488

# IfcFlowTerminal: Deca_Shared_Coluna para Tanque_TQ.03:CT.25_Branco Gelo GE17, Deca_Shared_Coluna para Tanque_TQ.03:CT.25_Branco Gelo GE17:1240547
In: Nível 1
Type - Classification: D2010400 Sinks (Uniformat); Material: Deca GE17 Branco Gelo Cerâmica
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deca
Type - Pset_QuantityTakeOff - Reference: CT.25_Branco Gelo GE17
Pset_DistributionFlowElementCommon - Reference: CT.25_Branco Gelo GE17; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: Deca_Tanque_TQ.03_40 Litros:TQ.03_Branco Gelo GE17, Deca_Tanque_TQ.03_40 Litros:TQ.03_Branco Gelo GE17:1240546
In: Nível 1
Type - Classification: D2010400 Sinks (Uniformat); Material: Deca GE17 Branco Gelo Cerâmica (2)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deca
Type - Pset_QuantityTakeOff - Reference: TQ.03_Branco Gelo GE17
Material: Deca GE17 Branco Gelo Cerâmica
Pset_DistributionFlowElementCommon - Reference: TQ.03_Branco Gelo GE17; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: FDE_BR03_ConjuntoLavatórioeBaciaAcessíveis:BR03_ConjuntoLavatórioeBaciaAcessíveis_ComVálvulaDeDescarga_DN32mm(1 1/4") (2)
In: Nível 1
Type - Classification: 08.16.091 (Uniformat); Material: FDE_AçoCromado, FDE_CerâmicaEsmaltadaBranca, FDE_ResinaPosliéster (Branco), FDE_AçoInox
Type - Pset_QuantityTakeOff - Reference: BR03_ConjuntoLavatórioeBaciaAcessíveis_ComVálvulaDeDescarga_DN32mm(1 1/4")
Pset_DistributionFlowElementCommon - Reference: BR03_ConjuntoLavatórioeBaciaAcessíveis_ComVálvulaDeDescarga_DN32mm(1 1/4"); sets with these values: 3
Name (FDE_BR03_ConjuntoLavatórioeBaciaAcessíveis:BR03_ConjuntoLavatórioeBaciaAcessíveis_ComVálvulaDeDescarga_DN32mm(1 1/4"):...)
1233126
1233129 | Group: Sanitário 2; Sanitário 3

# IfcFlowTerminal: FDE_H613_DispositivosRestritoresDeVazão:H613_RestritorDeVazãoPara6L/minTorneiraseMisturadores (2)
In: Nível 1
Type - Classification: 08.17.078 (Uniformat)
Type - Pset_QuantityTakeOff - Reference: H613_RestritorDeVazãoPara6L/minTorneiraseMisturadores
Pset_DistributionFlowElementCommon - Reference: H613_RestritorDeVazãoPara6L/minTorneiraseMisturadores; sets with these values: 3
Name (FDE_H613_DispositivosRestritoresDeVazão:H613_RestritorDeVazãoPara6L/minTorneiraseMisturadores:...)
1233127
1233131

# IfcFlowTerminal: Pia de parede:455 x 360 x 850mm (2)
In: Nível 1
Type - Material: <Unnamed> (2)
Type - Pset_QuantityTakeOff - Reference: 455 x 360 x 850mm
Pset_DistributionFlowElementCommon - Reference: 455 x 360 x 850mm; sets with these values: 3
Name (Pia de parede:455 x 360 x 850mm:...)
1236456
1238558

# IfcFlowTerminal: Prolongador - Caixas de Gordura e Inspecao - Esgoto - MEP - Tigre:Com entrada - Corpo 300mm/Tubo 100mm, Prolongador - Caixas de Gordura e Inspecao - Esgoto - MEP - Tigre:Com entrada - Corpo 300mm/Tubo 100mm:1254982
In: Nível 1
Type - Material: Tigre - Cx Gordura_Corpo
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Type - Pset_QuantityTakeOff - Reference: Com entrada - Corpo 300mm/Tubo 100mm
Pset_DistributionFlowElementCommon - Reference: Com entrada - Corpo 300mm/Tubo 100mm; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: Sifao para cozinha - DocolBasicos:1 1/2" (3)
In: Nível 1
Type - Material: Cromado - Docol
Type - Pset_ManufacturerTypeInformation - Manufacturer: Docol
Type - Pset_QuantityTakeOff - Reference: 1 1/2"
Pset_DistributionFlowElementCommon - Reference: 1 1/2"; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Name (Sifao para cozinha - DocolBasicos:1 1/2":...)
1256722 | Group: Sanitário 25
1256730
1256738

# IfcFlowTerminal: Sifao para lavatorio - DocolBasicos1:Lavatório Top 2 (6)
In: Nível 1
Type - Material: Cromado - Docol
Type - Pset_ManufacturerTypeInformation - Manufacturer: Docol
Type - Pset_QuantityTakeOff - Reference: Lavatório Top 2
Pset_DistributionFlowElementCommon - Reference: Lavatório Top 2; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Name (Sifao para lavatorio - DocolBasicos1:Lavatório Top 2:...)
1212648
1212649 | Group: Sanitário 1
1212650
1212655
1212656
1212658

# IfcFlowTerminal: Torneira 1:Torneira 1 (4)
In: Nível 1
Type - Material: <Unnamed>
Type - Pset_QuantityTakeOff - Reference: Torneira 1
Pset_DistributionFlowElementCommon - Reference: Torneira 1; sets with these values: 3
Name (Torneira 1:Torneira 1:...)
1236457
1236458
1238559
1238560

# IfcFlowTerminal: Torneira 3:Torneira 3 (2)
In: Nível 1
Type - Material: <Unnamed>
Type - Pset_QuantityTakeOff - Reference: Torneira 3
Pset_DistributionFlowElementCommon - Reference: Torneira 3; sets with these values: 3
Name (Torneira 3:Torneira 3:...)
1236459
1238561
