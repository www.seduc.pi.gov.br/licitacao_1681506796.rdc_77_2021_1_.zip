Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowSegment: Conduite sem conexões:Eletroduto Flexivel Corrugado de PVC amarelo_Tigreflex (510)
Name (Conduite sem conexões:Eletroduto Flexivel Corrugado de PVC amarelo_Tigreflex:...) | Length (m)
5468214 | 0.323792
5468216 | 1.471
5468230 | 0.323792
5468232 | 1.4815
5468246 | 1.8835
5468249 | 2.3383
5468634 | 2.44724
5468695 | 6.18005
5468704 | 1.6085
5468727 | 2.20086
5468737 | 0.145506
5468744 | 0.145396
5468754 | 2.15641
5468771 | 0.0957301
5468772 | 0.0667802
5468784 | 0.0957301
5468785 | 0.0667802
5468798 | 3.17527
5468808 | 2.15657
5468821 | 0.0957221
5468822 | 0.0667679
5468834 | 0.0957221
5468835 | 0.0667679
5468848 | 2.49823
5468865 | 1.38864
5468880 | 0.0959534
5468881 | 0.0671237
5468892 | 1.60926
5468902 | 1.18278
5468914 | 0.128672
5468921 | 2.40926
5468930 | 0.350005
5468939 | 2.3824
5468991 | 0.390005
5469000 | 0.875292
5469009 | 0.803873
5469022 | 0.075004
5469040 | 2.3593
5469045 | 1.06465
5469058 | 0.144922
5469072 | 0.313474
5469082 | 0.325281
5469111 | 3.79577
5469383 | 1.05891
5469397 | 0.409258
5469415 | 0.969147
5469427 | 0.0755802
5469430 | 2.68141
5469451 | 0.409258
5469460 | 0.509748
5469502 | 0.4295
5469512 | 1.09
5469520 | 0.9395
5469530 | 1.09
5469539 | 1.18542
5469549 | 1.09
5469557 | 0.251084
5469568 | 1.09
5469582 | 0.136279
5469592 | 1.09
5469624 | 0.551729
5469634 | 0.93
5469642 | 1.79123
5469652 | 0.93
5469661 | 0.212033
5469671 | 0.93
5469680 | 0.838
5469690 | 0.93
5469698 | 0.689724
5469709 | 0.93
5469727 | 0.982685
5469737 | 0.93
5469745 | 3.83622
5469756 | 0.93
5469823 | 0.93
5469848 | 0.731621
5470366 | 0.649
5470375 | 3.208
5470384 | 4.0222
5470724 | 0.12126
5470731 | 0.9175
5470930 | 0.445633
5470942 | 0.0161931
5470945 | 8.34734
5470963 | 0.409258
5470972 | 1.21755
5470984 | 0.0761748
5470987 | 0.245273
5471007 | 0.409258
5471311 | 0.598169
5471321 | 0.130016
5471328 | 1.60926
5471884 | 1.93237
5471892 | 9.438
5471901 | 0.749012
5472243 | 0.102312
5472250 | 0.976
5472264 | 0.520641
5472279 | 0.409258
5472288 | 0.18813
5472300 | 0.191816
5472303 | 2.01661
5472324 | 0.409258
5472459 | 3.7784
5473108 | 0.512652
5473118 | 0.126459
5473125 | 1.60926
5473134 | 0.543067
5473144 | 0.129542
5473151 | 1.60926
5473190 | 2.00887
5473200 | 0.133916
5473207 | 1.60926
5473657 | 0.234734
5473754 | 2.02717
5473773 | 2.3593
5473814 | 2.15287
5473830 | 0.338816
5473840 | 0.341867
5475150 | 0.11996
5475168 | 0.122201
5475175 | 0.0436849
5475185 | 1.87691
5475257 | 0.481565
5475267 | 1.015
5475297 | 9.958
5475305 | 0.361595
5475341 | 0.879435
5475351 | 1.09
5475417 | 1.06353
5475426 | 0.0808721
5475442 | 6.42736
5475450 | 7.518
5475458 | 16.868
5475468 | 0.356578
5475607 | 0.920135
5475617 | 1.09
5478204 | 3.4784
5478245 | 3.9884
5478257 | 4.39425
5478269 | 0.136098
5478276 | 0.135737
5478286 | 4.20482
5478296 | 0.142545
5478303 | 0.119804
5478314 | 4.03476
5478324 | 2.6834
5478334 | 2.6734
5478344 | 4.24793
5478354 | 0.14215
5478361 | 0.14198
5478371 | 4.01991
5478381 | 0.139261
5478388 | 0.12401
5478410 | 3.2184
5478422 | 3.2184
5478435 | 0.629
5478444 | 1.45074
5479168 | 0.9422
5479181 | 0.976
