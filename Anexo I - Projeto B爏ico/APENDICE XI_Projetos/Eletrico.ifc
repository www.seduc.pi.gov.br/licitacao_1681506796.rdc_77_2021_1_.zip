Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-06-16T13:07:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.11.27 - Exporter 21.1.11.27 - IU alternativa 21.1.11.27
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 16 13:07:12 2021 * Host: LAPTOP-D06TDN94 * Database: C:\Users\PAULAT~1\AppData\Local\Temp\4635c08b-ae0a-4f26-9cb2-6a9597644325\42294475-cb8e-4d30-ba31-c94358d324fc\ifc * Database version: 5507 * Database creation date: Wed Jun 16 13:06:47 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 16 13:06:47 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 16 13:06:47 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 m

# IfcBuilding, C.L. MONSENHOR ANTÔNIO SAMPAIO
LongName: C.L. MONSENHOR ANTÔNIO SAMPAIO
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Nível:8mm Head, Planta Baixa - Elétrico
In: C.L. MONSENHOR ANTÔNIO SAMPAIO
LongName: Planta Baixa - Elétrico; Elevation: 1.2 m

# IfcBuildingElementProxy: 1.a_1 Interruptor_Conjunto 4x2:a.Simples (7)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: a.Simples
Type - Pset_ManufacturerTypeInformation - Manufacturer: Pial Legrand ou equivalente
Type - Pset_QuantityTakeOff - Reference: a.Simples
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (1.a_1 Interruptor_Conjunto 4x2:a.Simples:...) | Group
5459103 | 2.1
5463199 | 1.1
5463224 | 1.1
5466543 | 3.1
5466568 | 3.1
5466593 | 3.1
5471278 | 1.1

# IfcBuildingElementProxy: 1.a_1 Tomada 2P+T_Conjunto 4x2:a. Tomada 2P+T 10A (31)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: a. Tomada 2P+T 10A
Type - Pset_ManufacturerTypeInformation - Manufacturer: Pial legrand ou equivalente
Type - Pset_QuantityTakeOff - Reference: a. Tomada 2P+T 10A
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (1.a_1 Tomada 2P+T_Conjunto 4x2:a. Tomada 2P+T 10A:...) | Group
5464058 | 1.7
5464083 | 1.7
5464108 | 1.7
5464133 | 1.7
5466034 | 3.3
5466059 | 3.3
5466084 | 3.3
5466109 | 3.3
5466134 | 3.3
5466159 | 3.3
5466351 | 3.4
5466463 | 3.4
5466489 | 3.4
5467419 | 3.5
5467444 | 3.5
5467469 | 3.5
5467832 | 3.4
5467835 | 3.4
5467838 | 3.4
5467865 | 3.4
5467868 | 3.4
5467871 | 3.4
5468156 | 3.5
5468159 | 3.5
5468162 | 3.5
5468174 | 3.5
5468177 | 3.5
5468180 | 3.5
5468192 | 3.5
5468195 | 3.5
5468198 | 3.5

# IfcBuildingElementProxy: 1.b_2 Interruptores_Conjunto 4x2:a. 2 Teclas Simples (9)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: a. 2 Teclas Simples
Type - Pset_ManufacturerTypeInformation - Manufacturer: Pial Legrand ou equivalente
Type - Pset_QuantityTakeOff - Reference: a. 2 Teclas Simples
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (1.b_2 Interruptores_Conjunto 4x2:a. 2 Teclas Simples:...)
5458433
5458502
5460709
5461226
5461959
5462052
5462190
5464183
5465934

# IfcBuildingElementProxy: 1.b_2 Tomadas 2P+T_Conjunto 4x2:a. 2 Tomadas 2P+T 10A (37)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: a. 2 Tomadas 2P+T 10A
Type - Pset_ManufacturerTypeInformation - Manufacturer: Pial Legrand ou equivalente
Type - Pset_QuantityTakeOff - Reference: a. 2 Tomadas 2P+T 10A
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (1.b_2 Tomadas 2P+T_Conjunto 4x2:a. 2 Tomadas 2P+T 10A:...)
5458754
5458779
5458804
5458829
5458854
5458879
5460534
5460559
5460584
5460609
5461206
5461211
5461216
5461221
5461939
5461944
5461949
5461954
5462032
5462037
5462042
5462047
5462170
5462175
5462180
5462185
5462355
5462494
5463049
5463098
5463123
5463148
5463952
5463977
5464002
5464027
5465983

# IfcBuildingElementProxy: 1.d Ponto de Força Saida de Fio_Conjunto 4x2:Ponto de Força Saida de Fio (21)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: Ponto de Força Saida de Fio
Type - Pset_ManufacturerTypeInformation - Manufacturer: Pial Legrand ou equivalente
Type - Pset_QuantityTakeOff - Reference: Ponto de Força Saida de Fio
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (1.d Ponto de Força Saida de Fio_Conjunto 4x2:Ponto de Força Saida de Fio:...) | Group
5458921 | 2.3
5458977 | 2.4
5459003 | 2.5
5459029 | 2.6
5459055 | 2.7
5460761 | 1.8
5460787 | 1.9
5461231 | 1.11
5461234 | 1.10
5461964 | 1.17
5461967 | 1.16
5462057 | 1.14
5462060 | 1.15
5462195 | 1.19
5462198 | 1.18
5463278 | 1.12
5463305 | 1.13
5463759 | 1.21
5463785 | 1.20
5469184 | 3.6
5469213 | 3.7

# IfcBuildingElementProxy: 1.e_1 Tomada+1 Interruptor_Conjunto 4x2:a.1 Simples + 1 Tomada 10A (7)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: a.1 Simples + 1 Tomada 10A
Type - Pset_ManufacturerTypeInformation - Manufacturer: Pial Legrand ou equivalente
Type - Pset_QuantityTakeOff - Reference: a.1 Simples + 1 Tomada 10A
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (1.e_1 Tomada+1 Interruptor_Conjunto 4x2:a.1 Simples + 1 Tomada 10A:...)
5458570
5458683
5464633
5465798
5465826
5465854
5465882

# IfcBuildingElementProxy: Mini Disjuntor Bipolar_Steck:b. Mini Disjuntor Bipolar 16A_Curva B, Mini Disjuntor Bipolar_Steck:b. Mini Disjuntor Bipolar 16A_Curva B:5458184
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica (2), PVC Antichama Vermelho Elétrica, Default
Type - Pset_BuildingElementProxyCommon - Reference: b. Mini Disjuntor Bipolar 16A_Curva B
Type - Pset_ManufacturerTypeInformation - Manufacturer: Steck ou equivalente
Type - Pset_QuantityTakeOff - Reference: b. Mini Disjuntor Bipolar 16A_Curva B
Material: Default, PVC Antichama Branco Elétrica, PVC Antichama Vermelho Elétrica
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: Mini Disjuntor Monopolar_Steck:a. Mini Disjuntor Monopolar 10A_Curva B (6)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Vermelho Elétrica, PVC Antichama Branco Elétrica (2), Default
Type - Pset_BuildingElementProxyCommon - Reference: a. Mini Disjuntor Monopolar 10A_Curva B
Type - Pset_ManufacturerTypeInformation - Manufacturer: Steck ou equivalente
Type - Pset_QuantityTakeOff - Reference: a. Mini Disjuntor Monopolar 10A_Curva B
Material: Default, PVC Antichama Branco Elétrica, PVC Antichama Vermelho Elétrica
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (Mini Disjuntor Monopolar_Steck:a. Mini Disjuntor Monopolar 10A_Curva B:...)
5465555
5469912
5469914
5469916
5469918
5469919

# IfcBuildingElementProxy: Mini Disjuntor Monopolar_Steck:b. Mini Disjuntor Monopolar 16A_Curva B (10)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Vermelho Elétrica, PVC Antichama Branco Elétrica (2), Default
Type - Pset_BuildingElementProxyCommon - Reference: b. Mini Disjuntor Monopolar 16A_Curva B
Type - Pset_ManufacturerTypeInformation - Manufacturer: Steck ou equivalente
Type - Pset_QuantityTakeOff - Reference: b. Mini Disjuntor Monopolar 16A_Curva B
Material: Default, PVC Antichama Branco Elétrica, PVC Antichama Vermelho Elétrica
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (Mini Disjuntor Monopolar_Steck:b. Mini Disjuntor Monopolar 16A_Curva B:...)
5458183
5465556
5465557
5465558
5465559
5469901
5469902
5469903
5469913
5469917

# IfcBuildingElementProxy: Mini Disjuntor Monopolar_Steck:c. Mini Disjuntor Monopolar 20A_Curva B (20)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica (2), PVC Antichama Vermelho Elétrica, Default
Type - Pset_BuildingElementProxyCommon - Reference: c. Mini Disjuntor Monopolar 20A_Curva B
Type - Pset_ManufacturerTypeInformation - Manufacturer: Steck ou equivalente
Type - Pset_QuantityTakeOff - Reference: c. Mini Disjuntor Monopolar 20A_Curva B
Material: Default, PVC Antichama Branco Elétrica, PVC Antichama Vermelho Elétrica
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (Mini Disjuntor Monopolar_Steck:c. Mini Disjuntor Monopolar 20A_Curva B:...)
5458185
5458186
5458187
5458188
5458189
5465560
5465561
5469904
5469905
5469906
5469907
5469908
5469909
5469910
5469911
5469915
5469920
5469922
5469923
5469924

# IfcBuildingElementProxy: Mini Disjuntor Monopolar_Steck:i. Mini Disjuntor Monopolar 20A_Curva C, Mini Disjuntor Monopolar_Steck:i. Mini Disjuntor Monopolar 20A_Curva C:5469921
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica (2), PVC Antichama Vermelho Elétrica, Default
Type - Pset_BuildingElementProxyCommon - Reference: i. Mini Disjuntor Monopolar 20A_Curva C
Type - Pset_ManufacturerTypeInformation - Manufacturer: Steck ou equivalente
Type - Pset_QuantityTakeOff - Reference: i. Mini Disjuntor Monopolar 20A_Curva C
Material: Default, PVC Antichama Branco Elétrica, PVC Antichama Vermelho Elétrica
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: Mini Disjuntor Tripolar_Steck:f. Mini Disjuntor Tripolar 40A_Curva C (2)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica (2), PVC Antichama Vermelho Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: f. Mini Disjuntor Tripolar 40A_Curva C
Type - Pset_ManufacturerTypeInformation - Manufacturer: Steck ou equivalente
Type - Pset_QuantityTakeOff - Reference: f. Mini Disjuntor Tripolar 40A_Curva C
Material: PVC Antichama Branco Elétrica, PVC Antichama Vermelho Elétrica, Default
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (Mini Disjuntor Tripolar_Steck:f. Mini Disjuntor Tripolar 40A_Curva C:...)
5474871
5474872

# IfcBuildingElementProxy: Mini Disjuntor Tripolar_Steck:l. Mini Disjuntor Tripolar 125A_Curva C, Mini Disjuntor Tripolar_Steck:l. Mini Disjuntor Tripolar 125A_Curva C:5474870
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica (2), PVC Antichama Vermelho Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: l. Mini Disjuntor Tripolar 125A_Curva C
Type - Pset_ManufacturerTypeInformation - Manufacturer: Steck ou equivalente
Type - Pset_QuantityTakeOff - Reference: l. Mini Disjuntor Tripolar 125A_Curva C
Material: PVC Antichama Branco Elétrica, PVC Antichama Vermelho Elétrica, Default
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: Quadro de Distribuição 12-16 Disjuntores de embutir em PVC:Quadro de Distribuição 12-16 Disjuntores de embutir em PVC, Quadro de Distribuição 12-16 Disjuntores de embutir em PVC:QD 02:5458182
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: Quadro de Distribuição 12-16 Disjuntores de embutir em PVC
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre ou equivalente
Type - Pset_QuantityTakeOff - Reference: Quadro de Distribuição 12-16 Disjuntores de embutir em PVC
Pset_BuildingElementProxyCommon - sets with these values: 2
Group: 2.7; 2.6; 2.5; 2.4; 2.3; 2.2; 2.1; 4,5,6

# IfcBuildingElementProxy: Quadro de Distribuição 27-36 Disjuntores de embutir em PVC:Quadro de Distribuição 27-36 Disjuntores de embutir em PVC, Quadro de Distribuição 27-36 Disjuntores de embutir em PVC:QD 01:5460083
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: Quadro de Distribuição 27-36 Disjuntores de embutir em PVC
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre ou equivalente
Type - Pset_QuantityTakeOff - Reference: Quadro de Distribuição 27-36 Disjuntores de embutir em PVC
Pset_BuildingElementProxyCommon - sets with these values: 2
Group: 1.24; 1.23; 1.22; 1.21; 1.20; 1.19; 1.18; 1.17; 1.16; 1.15; 1.14; 1.13; 1.12; 1.11; 1.10; 1.9; 1.8; 1.7; 1.6; 1.5; 1.4; 1.3; 1.2; 1.1; 1,2,3

# IfcBuildingElementProxy: Quadro de Distribuição 6-8 Disjuntores de embutir em PVC:Quadro de Distribuição 6-8 Disjuntores de embutir em PVC (2)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: Quadro de Distribuição 6-8 Disjuntores de embutir em PVC
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre ou equivalente
Type - Pset_QuantityTakeOff - Reference: Quadro de Distribuição 6-8 Disjuntores de embutir em PVC
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (Quadro de Distribuição 6-8 Disjuntores de embutir em PVC:...) | Group
QD 03:5465554 | 7,8,9; 3.7; 3.6; 3.5; 3.4; 3.3; 3.2; 3.1
QDG:5474672 | <não nomeado>; 7,8,9; 4,5,6; 1,2,3

# IfcBuildingElementProxy: x. Módulo de Tecla Interrupor não listavel 4:x. Módulo de Tecla Interrupor não listavel 4 (7)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: x. Módulo de Tecla Interrupor não listavel 4
Type - Pset_ManufacturerTypeInformation - Manufacturer: Não Listar
Type - Pset_QuantityTakeOff - Reference: x. Módulo de Tecla Interrupor não listavel 4
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (x. Módulo de Tecla Interrupor não listavel 4:x. Módulo de Tecla Interrupor não listavel 4:...) | Group
5458573 | 2.1 | Pset_ProvisionForVoid - Width: 0.018 m; Depth: 0.018 m
5458686 | 2.1
5464636 | 1.1
5465801 | 3.1
5465829 | 3.1
5465857 | 3.1
5465885 | 3.1

# IfcBuildingElementProxy: x. Módulo de Tecla Interrupor não listavel 5_2 teclas:x. Módulo de Tecla Interrupor não listavel 5_2 teclas (9)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: x. Módulo de Tecla Interrupor não listavel 5_2 teclas
Type - Pset_ManufacturerTypeInformation - Manufacturer: Não Listar
Type - Pset_QuantityTakeOff - Reference: x. Módulo de Tecla Interrupor não listavel 5_2 teclas
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (x. Módulo de Tecla Interrupor não listavel 5_2 teclas:x. Módulo de Tecla Interrupor não listavel 5_2 teclas:...) | Group
5458481 | 2.1 | Pset_ProvisionForVoid - Width: 0.018 m; Depth: 0.018 m
5458504 | 2.1
5460711 | 1.1
5461228 | 1.1 | Pset_ProvisionForVoid - Width: 0.018 m; Depth: 0.018 m
5461961 | 1.2
5462054 | 1.2
5462192 | 1.2
5464185 | 1.1
5465936 | 3.1

# IfcBuildingElementProxy: x. Módulo de Tecla Interrupor não listavel 6_2 teclas:x. Módulo de Tecla Interrupor não listavel 6_2 teclas (9)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: x. Módulo de Tecla Interrupor não listavel 6_2 teclas
Type - Pset_ManufacturerTypeInformation - Manufacturer: Não Listar
Type - Pset_QuantityTakeOff - Reference: x. Módulo de Tecla Interrupor não listavel 6_2 teclas
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (x. Módulo de Tecla Interrupor não listavel 6_2 teclas:x. Módulo de Tecla Interrupor não listavel 6_2 teclas:...) | Group
5458482 | 2.1 | Pset_ProvisionForVoid - Width: 0.018 m; Depth: 0.018 m
5458505 | 2.1
5460712 | 1.1
5461229 | 1.1 | Pset_ProvisionForVoid - Width: 0.018 m; Depth: 0.018 m
5461962 | 1.2
5462055 | 1.2
5462193 | 1.2
5464186 | 1.1
5465937 | 3.1

# IfcBuildingElementProxy: x.Módulo de Tomada não listavel 2:x.Módulo de Tomada não listavel 2 (74)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: x.Módulo de Tomada não listavel 2
Type - Pset_ManufacturerTypeInformation - Manufacturer: Não Listar
Type - Pset_QuantityTakeOff - Reference: x.Módulo de Tomada não listavel 2
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (x.Módulo de Tomada não listavel 2:x.Módulo de Tomada não listavel 2:...) | Group
5458756 | 2.2 | Pset_ProvisionForVoid - Width: 0.0140231 m; Height: 0.018 m; Depth: 0.0140231 m
5458757 | 2.2 | Pset_ProvisionForVoid - Width: 0.0140231 m; Height: 0.018 m; Depth: 0.0140231 m
5458781 | 2.2
5458782 | 2.2
5458806 | 2.2
5458807 | 2.2
5458831 | 2.2
5458832 | 2.2
5458856 | 2.2
5458857 | 2.2
5458881 | 2.2
5458882 | 2.2
5460536 | 1.3
5460537 | 1.3
5460561 | 1.3
5460562 | 1.3
5460586 | 1.3
5460587 | 1.3
5460611 | 1.3
5460612 | 1.3
5461208 | 1.3 | Pset_ProvisionForVoid - Width: 0.0140231 m; Height: 0.018 m; Depth: 0.0140231 m
5461209 | 1.3 | Pset_ProvisionForVoid - Width: 0.0140231 m; Height: 0.018 m; Depth: 0.0140231 m
5461213 | 1.3
5461214 | 1.3
5461218 | 1.3
5461219 | 1.3
5461223 | 1.3
5461224 | 1.3
5461941 | 1.5
5461942 | 1.5
5461946 | 1.5
5461947 | 1.5
5461951 | 1.5
5461952 | 1.5
5461956 | 1.5
5461957 | 1.5
5462034 | 1.5
5462035 | 1.5
5462039 | 1.5
5462040 | 1.5
5462044 | 1.5
5462045 | 1.5
5462049 | 1.5
5462050 | 1.5
5462172 | 1.6
5462173 | 1.6
5462177 | 1.6
5462178 | 1.6
5462182 | 1.6
5462183 | 1.6
5462187 | 1.6
5462188 | 1.6
5462357 | 1.6 | Pset_ProvisionForVoid - Width: 0.0140231 m; Height: 0.018 m; Depth: 0.0140231 m
5462358 | 1.6 | Pset_ProvisionForVoid - Width: 0.0140231 m; Height: 0.018 m; Depth: 0.0140231 m
5462496 | 1.6
5462497 | 1.6
5463051 | 1.4
5463052 | 1.4
5463100 | 1.4
5463101 | 1.4
5463125 | 1.4
5463126 | 1.4
5463150 | 1.4
5463151 | 1.4
5463954 | 1.7
5463955 | 1.7
5463979 | 1.7
5463980 | 1.7
5464004 | 1.7
5464005 | 1.7
5464029 | 1.7
5464030 | 1.7
5465985 | 3.4
5465986 | 3.4

# IfcBuildingElementProxy: x.Módulo de Tomada não listavel 4:x.Módulo de Tomada não listavel 4 (7)
In: Planta Baixa - Elétrico
Type - Material: PVC Antichama Branco Elétrica
Type - Pset_BuildingElementProxyCommon - Reference: x.Módulo de Tomada não listavel 4
Type - Pset_ManufacturerTypeInformation - Manufacturer: Não Listar
Type - Pset_QuantityTakeOff - Reference: x.Módulo de Tomada não listavel 4
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (x.Módulo de Tomada não listavel 4:x.Módulo de Tomada não listavel 4:...) | Group
5458572 | 2.2 | Pset_ProvisionForVoid - Width: 0.0140231 m; Height: 0.018 m; Depth: 0.0140231 m
5458685 | 2.2
5464635 | 1.7
5465800 | 3.2
5465828 | 3.2
5465856 | 3.2
5465884 | 3.2

# IfcDistributionPort (3154)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
2 x InPort_5457986
2 x OutPort_5458016
2 x OutPort_5458010
InPort_5458001
InPort_5458008
2 x InPort_5458018
2 x OutPort_5458056
2 x OutPort_5458052
InPort_5458033
2 x OutPort_5458037
2 x InPort_5458034
InPort_5458045
2 x OutPort_5458049
2 x InPort_5458046
20 x Port_5458182
5 x InPort_5458182
OutPort_5459980
OutPort_5459998
OutPort_5460023
OutPort_5459962
OutPort_5475267
12 x Port_5458433
InPort_5458433
OutPort_5459197
Port_5458481
Port_5458482
12 x Port_5458502
InPort_5458502
OutPort_5473207
Port_5458504
Port_5458505
12 x Port_5458570
InPort_5458570
OutPort_5473151
Port_5458572
Port_5458573
12 x Port_5458683
InPort_5458683
OutPort_5473125
Port_5458685
Port_5458686
11 x Port_5458754
2 x InPort_5458754
OutPort_5459234
2 x OutPort_5459358
Port_5458756
Port_5458757
11 x Port_5458779
2 x InPort_5458779
2 x OutPort_5459374
Port_5458781
Port_5458782
11 x Port_5458804
2 x InPort_5458804
2 x OutPort_5459392
Port_5458806
Port_5458807
12 x Port_5458829
InPort_5458829
Port_5458831
Port_5458832
12 x Port_5458854
InPort_5458854
OutPort_5459264
Port_5458856
Port_5458857
12 x Port_5458879
InPort_5458879
OutPort_5459290
Port_5458881
Port_5458882
13 x Port_5458921
InPort_5458921
OutPort_5459546
13 x Port_5458977
InPort_5458977
OutPort_5459614
13 x Port_5459003
InPort_5459003
OutPort_5459716
13 x Port_5459029
InPort_5459029
OutPort_5459776
13 x Port_5459055
InPort_5459055
OutPort_5459824
13 x Port_5459103
InPort_5459103
OutPort_5459332
2 x InPort_5459176
2 x OutPort_5459203
2 x OutPort_5459199
InPort_5459186
InPort_5459197
2 x InPort_5459214
2 x OutPort_5459242
2 x OutPort_5459238
InPort_5459227
InPort_5459234
2 x InPort_5459244
2 x OutPort_5459266
2 x OutPort_5459271
InPort_5459257
InPort_5459264
2 x InPort_5459273
2 x OutPort_5459297
2 x OutPort_5459292
InPort_5459283
InPort_5459290
InPort_5459308
2 x OutPort_5459341
2 x InPort_5459315
2 x OutPort_5459334
InPort_5459332
2 x InPort_5459417
OutPort_5459529
2 x OutPort_5459985
InPort_5459470
2 x OutPort_5459697
2 x InPort_5459480
OutPort_5459486
2 x OutPort_5460029
InPort_5459486
OutPort_5459803
InPort_5459521
2 x OutPort_5459554
InPort_5459529
OutPort_5459594
2 x InPort_5459531
2 x OutPort_5459550
InPort_5459546
2 x InPort_5459557
2 x OutPort_5459617
2 x OutPort_5459621
InPort_5459591
InPort_5459614
2 x InPort_5459686
2 x OutPort_5459724
2 x InPort_5459700
2 x OutPort_5459720
InPort_5459716
2 x InPort_5459727
2 x OutPort_5459783
2 x OutPort_5459779
InPort_5459753
InPort_5459776
2 x InPort_5459785
2 x OutPort_5459827
2 x OutPort_5459831
InPort_5459800
InPort_5459824
InPort_5459861
2 x OutPort_5459876
2 x InPort_5459870
2 x OutPort_5459967
InPort_5459896
2 x OutPort_5459911
2 x InPort_5459905
2 x OutPort_5460003
2 x InPort_5459952
2 x OutPort_5459964
InPort_5459962
2 x InPort_5459970
2 x OutPort_5459982
InPort_5459980
2 x InPort_5459988
2 x OutPort_5460000
InPort_5459998
2 x InPort_5460013
2 x OutPort_5460027
InPort_5460023
18 x Port_5460083
13 x InPort_5460083
OutPort_5472243
OutPort_5478996
OutPort_5469709
OutPort_5469756
OutPort_5469671
OutPort_5475175
OutPort_5470724
OutPort_5469690
OutPort_5469737
OutPort_5469823
OutPort_5469634
OutPort_5469652
OutPort_5479139
12 x Port_5460534
InPort_5460534
2 x OutPort_5461041
Port_5460536
Port_5460537
11 x Port_5460559
2 x InPort_5460559
OutPort_5460963
Port_5460561
Port_5460562
12 x Port_5460584
InPort_5460584
OutPort_5461017
Port_5460586
Port_5460587
12 x Port_5460609
InPort_5460609
OutPort_5460991
Port_5460611
Port_5460612
12 x Port_5460709
InPort_5460709
OutPort_5460927
Port_5460711
Port_5460712
13 x Port_5460761
InPort_5460761
OutPort_5462835
13 x Port_5460787
InPort_5460787
OutPort_5462810
2 x InPort_5460910
2 x OutPort_5460935
2 x OutPort_5460931
InPort_5460920
InPort_5460927
2 x InPort_5460946
2 x OutPort_5460970
2 x OutPort_5460965
InPort_5460956
InPort_5460963
2 x InPort_5460972
2 x OutPort_5460998
2 x OutPort_5460993
InPort_5460984
InPort_5460991
2 x InPort_5461000
2 x OutPort_5461024
2 x OutPort_5461019
InPort_5461010
InPort_5461017
12 x Port_5461206
InPort_5461206
2 x OutPort_5461279
Port_5461208
Port_5461209
11 x Port_5461211
2 x InPort_5461211
OutPort_5461342
Port_5461213
Port_5461214
12 x Port_5461216
InPort_5461216
OutPort_5461274
Port_5461218
Port_5461219
12 x Port_5461221
InPort_5461221
OutPort_5461266
Port_5461223
Port_5461224
12 x Port_5461226
InPort_5461226
OutPort_5461250
Port_5461228
Port_5461229
13 x Port_5461231
InPort_5461231
OutPort_5462728
13 x Port_5461234
InPort_5461234
OutPort_5462773
2 x InPort_5461247
2 x OutPort_5461253
2 x OutPort_5461251
InPort_5461249
InPort_5461250
2 x InPort_5461263
2 x OutPort_5461269
2 x OutPort_5461267
InPort_5461265
InPort_5461266
2 x InPort_5461271
2 x OutPort_5461277
2 x OutPort_5461275
InPort_5461273
InPort_5461274
2 x InPort_5461323
2 x OutPort_5461349
2 x OutPort_5461344
InPort_5461335
InPort_5461342
12 x Port_5461939
InPort_5461939
2 x OutPort_5462012
Port_5461941
Port_5461942
11 x Port_5461944
2 x InPort_5461944
OutPort_5461991
Port_5461946
Port_5461947
12 x Port_5461949
InPort_5461949
OutPort_5462007
Port_5461951
Port_5461952
12 x Port_5461954
InPort_5461954
OutPort_5461999
Port_5461956
Port_5461957
12 x Port_5461959
InPort_5461959
OutPort_5461983
Port_5461961
Port_5461962
13 x Port_5461964
InPort_5461964
OutPort_5472279
13 x Port_5461967
InPort_5461967
OutPort_5472324
2 x InPort_5461980
2 x OutPort_5461986
2 x OutPort_5461984
InPort_5461982
InPort_5461983
2 x InPort_5461988
2 x OutPort_5461992
2 x OutPort_5461994
InPort_5461990
InPort_5461991
2 x InPort_5461996
2 x OutPort_5462000
2 x OutPort_5462002
InPort_5461998
InPort_5461999
2 x InPort_5462004
2 x OutPort_5462010
2 x OutPort_5462008
InPort_5462006
InPort_5462007
12 x Port_5462032
InPort_5462032
2 x OutPort_5462097
Port_5462034
Port_5462035
11 x Port_5462037
2 x InPort_5462037
OutPort_5462102
Port_5462039
Port_5462040
12 x Port_5462042
InPort_5462042
OutPort_5462092
Port_5462044
Port_5462045
12 x Port_5462047
InPort_5462047
OutPort_5462084
Port_5462049
Port_5462050
12 x Port_5462052
InPort_5462052
OutPort_5462076
Port_5462054
Port_5462055
13 x Port_5462057
InPort_5462057
OutPort_5471007
13 x Port_5462060
InPort_5462060
OutPort_5470963
2 x InPort_5462073
2 x OutPort_5462077
2 x OutPort_5462079
InPort_5462075
InPort_5462076
2 x InPort_5462081
2 x OutPort_5462087
2 x OutPort_5462085
InPort_5462083
InPort_5462084
2 x InPort_5462089
2 x OutPort_5462095
2 x OutPort_5462093
InPort_5462091
InPort_5462092
2 x InPort_5462099
2 x OutPort_5462103
2 x OutPort_5462105
InPort_5462101
InPort_5462102
12 x Port_5462170
InPort_5462170
2 x OutPort_5462243
Port_5462172
Port_5462173
11 x Port_5462175
2 x InPort_5462175
OutPort_5462222
Port_5462177
Port_5462178
12 x Port_5462180
InPort_5462180
OutPort_5462238
Port_5462182
Port_5462183
InPort_5462185
OutPort_5462230
12 x Port_5462185
Port_5462187
Port_5462188
12 x Port_5462190
InPort_5462190
OutPort_5462327
Port_5462192
Port_5462193
13 x Port_5462195
InPort_5462195
OutPort_5465026
13 x Port_5462198
InPort_5462198
OutPort_5465081
2 x InPort_5462219
2 x OutPort_5462225
2 x OutPort_5462223
InPort_5462221
InPort_5462222
2 x InPort_5462227
2 x OutPort_5462231
2 x OutPort_5462233
InPort_5462229
InPort_5462230
2 x InPort_5462235
2 x OutPort_5462241
2 x OutPort_5462239
InPort_5462237
InPort_5462238
2 x InPort_5462310
2 x OutPort_5462334
2 x OutPort_5462329
InPort_5462320
InPort_5462327
12 x Port_5462355
InPort_5462355
OutPort_5462549
Port_5462357
Port_5462358
12 x Port_5462494
InPort_5462494
OutPort_5462575
Port_5462496
Port_5462497
2 x InPort_5462532
2 x OutPort_5462556
2 x OutPort_5462551
InPort_5462542
InPort_5462549
2 x InPort_5462558
2 x OutPort_5462582
2 x OutPort_5462577
InPort_5462568
InPort_5462575
2 x InPort_5462599
2 x OutPort_5462611
2 x OutPort_5462620
InPort_5462609
2 x InPort_5462614
2 x OutPort_5469639
InPort_5462644
2 x OutPort_5462720
InPort_5462663
OutPort_5462693
InPort_5462693
OutPort_5469848
2 x InPort_5462703
2 x OutPort_5462734
2 x OutPort_5462741
2 x InPort_5462718
InPort_5462728
InPort_5462749
2 x OutPort_5462775
InPort_5462773
2 x InPort_5462777
2 x OutPort_5462812
2 x OutPort_5462817
InPort_5462789
InPort_5462792
2 x OutPort_5462840
InPort_5462810
2 x InPort_5462819
2 x OutPort_5462837
InPort_5462835
11 x Port_5463049
2 x InPort_5463049
2 x OutPort_5463412
OutPort_5463437
Port_5463051
Port_5463052
11 x Port_5463098
2 x InPort_5463098
OutPort_5463377
2 x OutPort_5463396
Port_5463100
Port_5463101
12 x Port_5463123
InPort_5463123
Port_5463125
Port_5463126
12 x Port_5463148
InPort_5463148
Port_5463150
Port_5463151
13 x Port_5463199
InPort_5463199
OutPort_5463489
InPort_5463224
OutPort_5463463
13 x Port_5463224
13 x Port_5463278
InPort_5463278
OutPort_5463636
13 x Port_5463305
InPort_5463305
OutPort_5463661
2 x InPort_5463360
2 x OutPort_5463384
2 x OutPort_5463379
InPort_5463370
InPort_5463377
2 x InPort_5463420
2 x OutPort_5463439
2 x OutPort_5463444
InPort_5463430
InPort_5463437
2 x InPort_5463446
2 x OutPort_5463465
2 x OutPort_5463470
InPort_5463456
InPort_5463463
2 x InPort_5463472
2 x OutPort_5463496
2 x OutPort_5463491
InPort_5463482
InPort_5463489
InPort_5463498
2 x OutPort_5469657
InPort_5463528
2 x OutPort_5469676
2 x InPort_5463603
2 x OutPort_5463640
2 x OutPort_5463644
InPort_5463615
InPort_5463618
2 x OutPort_5463666
InPort_5463636
2 x InPort_5463646
2 x OutPort_5463664
InPort_5463661
2 x InPort_5463679
2 x OutPort_5463693
OutPort_5463704
InPort_5463691
InPort_5463704
OutPort_5463707
InPort_5463707
2 x OutPort_5469742
13 x Port_5463759
InPort_5463759
OutPort_5464858
13 x Port_5463785
InPort_5463785
OutPort_5464912
12 x Port_5463952
InPort_5463952
OutPort_5464531
Port_5463954
Port_5463955
11 x Port_5463977
2 x InPort_5463977
OutPort_5464266
2 x OutPort_5464287
Port_5463979
Port_5463980
12 x Port_5464002
InPort_5464002
Port_5464004
Port_5464005
12 x Port_5464027
InPort_5464027
OutPort_5464330
Port_5464029
Port_5464030
13 x Port_5464058
InPort_5464058
2 x OutPort_5464458
12 x Port_5464083
2 x InPort_5464083
2 x OutPort_5464442
12 x Port_5464108
2 x InPort_5464108
2 x OutPort_5464426
12 x Port_5464133
2 x InPort_5464133
OutPort_5464404
InPort_5464183
OutPort_5464362
12 x Port_5464183
Port_5464185
Port_5464186
2 x InPort_5464249
2 x OutPort_5464268
2 x OutPort_5464273
InPort_5464259
InPort_5464266
2 x InPort_5464313
2 x OutPort_5464333
2 x OutPort_5464337
InPort_5464323
InPort_5464330
InPort_5464339
2 x OutPort_5464371
2 x InPort_5464348
2 x OutPort_5464364
InPort_5464362
2 x InPort_5464378
2 x OutPort_5464411
2 x OutPort_5464390
InPort_5464388
2 x InPort_5464393
2 x OutPort_5464406
InPort_5464404
InPort_5464471
2 x OutPort_5464486
2 x InPort_5464478
2 x OutPort_5464495
2 x InPort_5464489
2 x OutPort_5469695
2 x InPort_5464514
2 x OutPort_5464533
2 x OutPort_5464538
InPort_5464524
InPort_5464531
InPort_5464633
OutPort_5464788
12 x Port_5464633
Port_5464635
Port_5464636
InPort_5464689
2 x OutPort_5464723
2 x InPort_5464698
2 x OutPort_5464714
InPort_5464712
2 x InPort_5464771
2 x OutPort_5464790
2 x OutPort_5464795
InPort_5464781
InPort_5464788
InPort_5464814
2 x OutPort_5469762
2 x InPort_5464842
2 x OutPort_5464860
OutPort_5464865
InPort_5464858
InPort_5464865
OutPort_5464891
2 x InPort_5464876
2 x OutPort_5464919
2 x OutPort_5464914
InPort_5464888
InPort_5464912
InPort_5464967
OutPort_5464981
InPort_5464975
2 x OutPort_5469716
InPort_5464981
OutPort_5470987
2 x InPort_5465010
2 x OutPort_5465032
OutPort_5465034
InPort_5465026
InPort_5465034
OutPort_5465060
2 x InPort_5465045
2 x OutPort_5465088
2 x OutPort_5465084
InPort_5465057
InPort_5465081
11 x Port_5465554
6 x InPort_5465554
OutPort_5469592
OutPort_5469512
OutPort_5469568
OutPort_5475426
OutPort_5469530
OutPort_5469549
12 x Port_5465798
InPort_5465798
OutPort_5467214
Port_5465800
Port_5465801
12 x Port_5465826
InPort_5465826
OutPort_5467162
Port_5465828
Port_5465829
12 x Port_5465854
InPort_5465854
OutPort_5467188
Port_5465856
Port_5465857
12 x Port_5465882
InPort_5465882
OutPort_5467240
Port_5465884
Port_5465885
12 x Port_5465934
InPort_5465934
OutPort_5468892
Port_5465936
Port_5465937
12 x Port_5465983
InPort_5465983
OutPort_5468921
Port_5465985
Port_5465986
13 x Port_5466034
InPort_5466034
2 x OutPort_5473840
12 x Port_5466059
2 x InPort_5466059
2 x OutPort_5473830
12 x Port_5466084
2 x InPort_5466084
OutPort_5473814
12 x Port_5466109
2 x InPort_5466109
OutPort_5467266
2 x OutPort_5467316
2 x InPort_5466134
2 x OutPort_5467357
12 x Port_5466134
13 x Port_5466159
InPort_5466159
12 x Port_5466351
2 x InPort_5466351
2 x OutPort_5467726
OutPort_5467806
12 x Port_5466463
2 x InPort_5466463
2 x OutPort_5467708
13 x Port_5466489
InPort_5466489
13 x Port_5466543
InPort_5466543
OutPort_5467680
13 x Port_5466568
InPort_5466568
OutPort_5467577
13 x Port_5466593
InPort_5466593
OutPort_5467626
2 x InPort_5466926
2 x OutPort_5466947
2 x OutPort_5466954
InPort_5466938
InPort_5466945
2 x InPort_5466956
2 x OutPort_5466981
2 x OutPort_5466988
InPort_5466967
2 x OutPort_5466971
2 x InPort_5466968
InPort_5466979
2 x InPort_5467000
2 x OutPort_5467026
2 x OutPort_5467019
InPort_5467010
InPort_5467017
2 x InPort_5467028
2 x OutPort_5467047
2 x OutPort_5467053
InPort_5467038
InPort_5467045
2 x InPort_5467055
2 x OutPort_5467074
2 x OutPort_5467080
InPort_5467065
InPort_5467072
InPort_5467082
2 x OutPort_5467097
2 x InPort_5467089
2 x OutPort_5467106
2 x InPort_5467100
2 x OutPort_5469517
2 x InPort_5467145
2 x OutPort_5467164
2 x OutPort_5467169
InPort_5467155
InPort_5467162
2 x InPort_5467171
2 x OutPort_5467190
2 x OutPort_5467195
InPort_5467181
InPort_5467188
2 x InPort_5467197
2 x OutPort_5467216
2 x OutPort_5467221
InPort_5467207
InPort_5467214
2 x InPort_5467223
2 x OutPort_5467242
2 x OutPort_5467247
InPort_5467233
InPort_5467240
2 x InPort_5467249
2 x OutPort_5467273
2 x OutPort_5467268
InPort_5467259
InPort_5467266
13 x Port_5467419
InPort_5467419
2 x OutPort_5469082
12 x Port_5467444
2 x InPort_5467444
2 x OutPort_5469072
12 x Port_5467469
2 x InPort_5467469
OutPort_5469058
2 x InPort_5467522
2 x OutPort_5467534
2 x OutPort_5467557
InPort_5467532
2 x InPort_5467537
2 x OutPort_5467550
InPort_5467548
2 x InPort_5467560
2 x OutPort_5467584
2 x OutPort_5467579
InPort_5467570
InPort_5467577
2 x InPort_5467609
2 x OutPort_5467633
2 x OutPort_5467628
InPort_5467619
InPort_5467626
2 x InPort_5467635
2 x OutPort_5467654
2 x OutPort_5467661
InPort_5467645
InPort_5467652
2 x InPort_5467663
2 x OutPort_5467685
2 x OutPort_5467689
InPort_5467673
InPort_5467680
InPort_5467806
2 x OutPort_5467810
2 x InPort_5467807
2 x OutPort_5468018
12 x Port_5467832
2 x InPort_5467832
OutPort_5467847
2 x OutPort_5467843
12 x Port_5467835
2 x InPort_5467835
2 x OutPort_5467841
13 x Port_5467838
InPort_5467838
InPort_5467847
2 x OutPort_5467849
2 x InPort_5467848
2 x OutPort_5467978
12 x Port_5467865
2 x InPort_5467865
2 x OutPort_5467876
OutPort_5467880
12 x Port_5467868
2 x InPort_5467868
2 x OutPort_5467874
13 x Port_5467871
InPort_5467871
InPort_5467880
2 x OutPort_5467882
2 x InPort_5467881
OutPort_5467884
InPort_5467884
OutPort_5467926
InPort_5467926
OutPort_5467940
InPort_5467940
OutPort_5467960
InPort_5467951
InPort_5467995
InPort_5468020
2 x OutPort_5468140
2 x InPort_5468126
OutPort_5468146
2 x OutPort_5468144
2 x InPort_5468138
InPort_5468146
OutPort_5468704
12 x Port_5468156
2 x InPort_5468156
OutPort_5468170
2 x OutPort_5468167
2 x InPort_5468159
2 x OutPort_5468165
12 x Port_5468159
13 x Port_5468162
InPort_5468162
InPort_5468170
2 x OutPort_5468172
2 x InPort_5468171
2 x OutPort_5468244
12 x Port_5468174
2 x InPort_5468174
2 x OutPort_5468185
OutPort_5468188
12 x Port_5468177
2 x InPort_5468177
2 x OutPort_5468183
13 x Port_5468180
InPort_5468180
InPort_5468188
2 x OutPort_5468190
2 x InPort_5468189
2 x OutPort_5468228
12 x Port_5468192
2 x InPort_5468192
2 x OutPort_5468203
OutPort_5468205
12 x Port_5468195
2 x InPort_5468195
2 x OutPort_5468201
13 x Port_5468198
InPort_5468198
InPort_5468205
2 x OutPort_5468207
2 x InPort_5468206
OutPort_5468209
InPort_5468209
OutPort_5468211
InPort_5468211
OutPort_5468212
InPort_5468212
OutPort_5468216
InPort_5468214
InPort_5468230
InPort_5468246
2 x OutPort_5468250
2 x InPort_5468249
2 x OutPort_5468719
InPort_5468634
2 x OutPort_5469597
InPort_5468695
2 x InPort_5468727
2 x OutPort_5468746
2 x OutPort_5468752
InPort_5468737
InPort_5468744
2 x InPort_5468754
2 x OutPort_5468791
2 x OutPort_5468795
InPort_5468771
2 x OutPort_5468775
2 x InPort_5468772
InPort_5468784
2 x OutPort_5468788
2 x InPort_5468785
2 x InPort_5468808
2 x OutPort_5468845
2 x OutPort_5468841
InPort_5468821
2 x OutPort_5468825
2 x InPort_5468822
InPort_5468834
2 x OutPort_5468838
2 x InPort_5468835
2 x InPort_5468865
2 x OutPort_5468894
2 x OutPort_5468899
InPort_5468880
2 x OutPort_5468884
2 x InPort_5468881
InPort_5468892
2 x InPort_5468902
2 x OutPort_5468928
2 x OutPort_5468923
InPort_5468914
InPort_5468921
InPort_5468930
2 x OutPort_5468947
2 x InPort_5468939
2 x OutPort_5469554
InPort_5468991
2 x OutPort_5469006
2 x InPort_5469000
2 x OutPort_5469019
2 x InPort_5469009
2 x OutPort_5469028
2 x InPort_5469022
2 x OutPort_5469043
2 x InPort_5469040
2 x OutPort_5469067
2 x InPort_5469045
2 x OutPort_5469060
InPort_5469058
InPort_5469111
2 x OutPort_5469574
13 x Port_5469184
InPort_5469184
OutPort_5469451
InPort_5469213
OutPort_5469397
13 x Port_5469213
2 x InPort_5469383
OutPort_5469404
2 x OutPort_5469399
InPort_5469397
InPort_5469404
OutPort_5469430
2 x InPort_5469415
2 x OutPort_5469453
2 x OutPort_5469458
InPort_5469427
InPort_5469451
InPort_5469460
2 x OutPort_5469535
2 x InPort_5469502
2 x OutPort_5469514
InPort_5469512
2 x InPort_5469520
2 x OutPort_5469532
InPort_5469530
2 x InPort_5469539
2 x OutPort_5469551
InPort_5469549
2 x InPort_5469557
2 x OutPort_5469570
InPort_5469568
2 x InPort_5469582
2 x OutPort_5469594
InPort_5469592
2 x InPort_5469624
2 x OutPort_5469636
InPort_5469634
2 x InPort_5469642
2 x OutPort_5469654
InPort_5469652
2 x InPort_5469661
2 x OutPort_5469673
InPort_5469671
2 x InPort_5469680
2 x OutPort_5469692
InPort_5469690
2 x InPort_5469698
2 x OutPort_5469711
InPort_5469709
2 x InPort_5469727
2 x OutPort_5469739
InPort_5469737
2 x InPort_5469745
2 x OutPort_5469758
InPort_5469756
InPort_5469823
2 x OutPort_5469856
InPort_5469848
InPort_5470366
2 x OutPort_5470381
2 x InPort_5470375
2 x OutPort_5470392
2 x InPort_5470384
2 x OutPort_5470733
InPort_5470724
2 x OutPort_5470735
2 x InPort_5470731
2 x InPort_5470930
2 x OutPort_5470970
2 x OutPort_5470965
InPort_5470942
InPort_5470963
2 x InPort_5470972
2 x OutPort_5471009
2 x OutPort_5471014
InPort_5470984
InPort_5471007
13 x Port_5471278
InPort_5471278
OutPort_5471328
2 x InPort_5471311
2 x OutPort_5471331
2 x OutPort_5471335
InPort_5471321
InPort_5471328
InPort_5471884
2 x OutPort_5471898
2 x InPort_5471892
2 x OutPort_5471909
2 x InPort_5471901
2 x OutPort_5472252
InPort_5472243
2 x OutPort_5472254
2 x InPort_5472250
2 x InPort_5472264
OutPort_5472285
2 x OutPort_5472283
InPort_5472279
InPort_5472285
OutPort_5472303
2 x InPort_5472288
2 x OutPort_5472331
2 x OutPort_5472327
InPort_5472300
InPort_5472324
2 x InPort_5473108
2 x OutPort_5473127
2 x OutPort_5473132
InPort_5473118
InPort_5473125
2 x InPort_5473134
2 x OutPort_5473158
2 x OutPort_5473153
InPort_5473144
InPort_5473151
2 x InPort_5473190
2 x OutPort_5473214
2 x OutPort_5473210
InPort_5473200
InPort_5473207
InPort_5473657
OutPort_5473659
InPort_5473659
OutPort_5473754
InPort_5473754
2 x OutPort_5473776
2 x InPort_5473773
2 x OutPort_5473826
InPort_5473814
3 x InPort_5474672
OutPort_5475168
14 x Port_5474672
OutPort_5475617
OutPort_5475351
2 x InPort_5475150
2 x OutPort_5475172
2 x OutPort_5475182
InPort_5475168
InPort_5475175
2 x InPort_5475185
2 x OutPort_5475272
OutPort_5475295
2 x InPort_5475257
2 x OutPort_5475269
InPort_5475267
InPort_5475295
OutPort_5475297
InPort_5475297
2 x OutPort_5475313
2 x InPort_5475305
2 x OutPort_5475356
2 x InPort_5475341
2 x OutPort_5475353
InPort_5475351
2 x InPort_5475417
2 x OutPort_5475428
OutPort_5475431
InPort_5475426
InPort_5475431
OutPort_5475442
InPort_5475442
2 x OutPort_5475456
2 x InPort_5475450
2 x OutPort_5475466
2 x InPort_5475458
2 x OutPort_5475474
2 x InPort_5475468
2 x OutPort_5475622
2 x InPort_5475607
2 x OutPort_5475619
InPort_5475617
2 x InPort_5476484
2 x OutPort_5476504
2 x OutPort_5476509
InPort_5476494
InPort_5476502
2 x InPort_5476701
2 x OutPort_5476721
2 x OutPort_5476726
InPort_5476711
InPort_5476719
InPort_5476768
2 x OutPort_5476788
2 x InPort_5476777
2 x OutPort_5476815
2 x InPort_5476791
2 x OutPort_5476810
InPort_5476803
2 x OutPort_5476807
2 x InPort_5476804
InPort_5476818
2 x OutPort_5476833
2 x InPort_5476825
2 x OutPort_5476861
2 x InPort_5476837
2 x OutPort_5476856
InPort_5476849
2 x OutPort_5476853
2 x InPort_5476850
InPort_5476904
2 x OutPort_5476947
InPort_5476939
2 x InPort_5477015
2 x OutPort_5477035
2 x OutPort_5477040
InPort_5477025
InPort_5477033
InPort_5477138
2 x OutPort_5477182
InPort_5477174
InPort_5477195
2 x OutPort_5477235
2 x InPort_5477204
2 x OutPort_5477228
InPort_5477221
2 x OutPort_5477225
2 x InPort_5477222
2 x InPort_5477274
2 x OutPort_5477292
OutPort_5477299
InPort_5477290
InPort_5477299
OutPort_5479406
InPort_5477306
2 x OutPort_5478818
2 x InPort_5477487
2 x OutPort_5477515
2 x OutPort_5477509
InPort_5477500
InPort_5477507
2 x InPort_5478257
2 x OutPort_5478284
2 x OutPort_5478278
InPort_5478269
InPort_5478276
2 x InPort_5478286
2 x OutPort_5478305
2 x OutPort_5478312
InPort_5478296
InPort_5478303
2 x InPort_5478344
2 x OutPort_5478363
2 x OutPort_5478369
InPort_5478354
InPort_5478361
2 x InPort_5478371
2 x OutPort_5478390
2 x OutPort_5478397
InPort_5478381
InPort_5478388
InPort_5478435
2 x OutPort_5478450
2 x InPort_5478444
2 x OutPort_5479187
2 x InPort_5478812
2 x OutPort_5479001
2 x InPort_5478987
2 x OutPort_5478998
InPort_5478996
InPort_5479139
2 x OutPort_5479183
2 x InPort_5479168
2 x OutPort_5479185
2 x InPort_5479181

# IfcFlowFitting: Condulete Top_Adaptador para Condulete de PVC:Condulete Top_Adaptador para Condulete de PVC (57)
In: Planta Baixa - Elétrico
Type - Material: Condulete Top Tigre
Type - Pset_DistributionFlowElementCommon - Reference: Condulete Top_Adaptador para Condulete de PVC
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre, Linha Condulete Top ou equivalente
Type - Pset_QuantityTakeOff - Reference: Condulete Top_Adaptador para Condulete de PVC
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Condulete Top_Adaptador para Condulete de PVC:Condulete Top_Adaptador para Condulete de PVC:...)
5459601
5459603
5459605
5459763
5459765
5459767
5459810
5459812
5459814
5462679
5462681
5462683
5462765
5462767
5462769
5462799
5462801
5462803
5463625
5463627
5463629
5464898
5464900
5464902
5465067
5465069
5465071
5467967
5467969
5467971
5468011
5468013
5468015
5468221
5468223
5468225
5468238
5468240
5468242
5468711
5468713
5468715
5469437
5469439
5469441
5470952
5470954
5470956
5470994
5470996
5470998
5472310
5472312
5472314
5477333
5477335
5477337

# IfcFlowFitting: Condulete Top_Condulete de PVC 5 entradas 1pol:Condulete Top_Condulete de PVC 5 entradas 1pol (19)
In: Planta Baixa - Elétrico
Type - Material: Condulete Top Tigre, PVC Antichama Branco Elétrica
Type - Pset_DistributionFlowElementCommon - Reference: Condulete Top_Condulete de PVC 5 entradas 1pol
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre, Linha Condulete Top ou equivalente
Type - Pset_QuantityTakeOff - Reference: Condulete Top_Condulete de PVC 5 entradas 1pol
Material: Condulete Top Tigre
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Condulete Top_Condulete de PVC 5 entradas 1pol:Condulete Top_Condulete de PVC 5 entradas 1pol:...)
5459597
5459759
5459806
5462675
5462761
5462795
5463621
5464894
5465063
5467963
5468007
5468217
5468234
5468707
5469433
5470948
5470990
5472306
5477329

# IfcFlowFitting: Condulete Top_Tampas Condulete de PVC:1.f Tampa cega (17)
In: Planta Baixa - Elétrico
Type - Material: Condulete Top Tigre, Tomada Conduletes
Type - Pset_DistributionFlowElementCommon - Reference: 1.f Tampa cega
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre, Linha Condulete Top ou equivalente
Type - Pset_QuantityTakeOff - Reference: 1.f Tampa cega
Material: Condulete Top Tigre
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Condulete Top_Tampas Condulete de PVC:1.f Tampa cega:...)
5459599
5459761
5459808
5462677
5462763
5462797
5463623
5464896
5465065
5467965
5468009
5468709
5469435
5470950
5470992
5472308
5477331

# IfcFlowFitting: Condulete Top_Tampas Condulete de PVC:1.f Tampa cega (2)
In: Planta Baixa - Elétrico
Type - Material: Tomada Conduletes, Condulete Top Tigre
Type - Pset_DistributionFlowElementCommon - Reference: 1.f Tampa cega
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre, Linha Condulete Top ou equivalente
Type - Pset_QuantityTakeOff - Reference: 1.f Tampa cega
Material: Condulete Top Tigre
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Condulete Top_Tampas Condulete de PVC:1.f Tampa cega:...)
5468219
5468236

# IfcFlowFitting: Curva Generica para Eletroduto Corrugado PVC Reforçado Laranja:Curva generica para eletroduto corrugado Reforçado (6)
In: Planta Baixa - Elétrico
Type - Material: Linha Corrugado PVC Reforçado Laranja Antichamas
Type - Pset_DistributionFlowElementCommon - Reference: Curva generica para eletroduto corrugado Reforçado
Type - Pset_ManufacturerTypeInformation - Manufacturer: Não Listar
Type - Pset_QuantityTakeOff - Reference: Curva generica para eletroduto corrugado Reforçado
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Curva Generica para Eletroduto Corrugado PVC Reforçado Laranja:Curva generica para eletroduto corrugado Reforçado:...)
5477509
5477515
5478818
5478998
5479001
5479183

# IfcFlowFitting: Curva Generica para Eletroduto Corrugado PVC amarelo:Curva generica para eletroduto corrugado Amarelo (312)
In: Planta Baixa - Elétrico
Type - Material: Linha Corrugado PVC Amarelo Antichamas
Type - Pset_DistributionFlowElementCommon - Reference: Curva generica para eletroduto corrugado Amarelo
Type - Pset_ManufacturerTypeInformation - Manufacturer: Não Listar
Type - Pset_QuantityTakeOff - Reference: Curva generica para eletroduto corrugado Amarelo
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Curva Generica para Eletroduto Corrugado PVC amarelo:Curva generica para eletroduto corrugado Amarelo:...)
5458010
5458016
5458037
5458049
5458052
5458056
5459199
5459203
5459238
5459242
5459266
5459271
5459292
5459297
5459334
5459341
5459486
5459529
5459550
5459554
5459617
5459621
5459697
5459720
5459724
5459779
5459783
5459827
5459831
5459876
5459911
5459964
5459967
5459982
5459985
5460000
5460003
5460027
5460029
5460931
5460935
5460965
5460970
5460993
5460998
5461019
5461024
5461251
5461253
5461267
5461269
5461275
5461277
5461344
5461349
5461984
5461986
5461992
5461994
5462000
5462002
5462008
5462010
5462077
5462079
5462085
5462087
5462093
5462095
5462103
5462105
5462223
5462225
5462231
5462233
5462239
5462241
5462329
5462334
5462551
5462556
5462577
5462582
5462611
5462620
5462693
5462720
5462734
5462741
5462775
5462812
5462817
5462837
5462840
5463379
5463384
5463439
5463444
5463465
5463470
5463491
5463496
5463640
5463644
5463664
5463666
5463693
5463704
5464268
5464273
5464333
5464337
5464364
5464371
5464390
5464406
5464411
5464486
5464495
5464533
5464538
5464714
5464723
5464790
5464795
5464860
5464865
5464914
5464919
5464981
5465032
5465034
5465084
5465088
5466947
5466954
5466971
5466981
5466988
5467019
5467026
5467047
5467053
5467074
5467080
5467097
5467106
5467164
5467169
5467190
5467195
5467216
5467221
5467242
5467247
5467268
5467273
5467534
5467550
5467557
5467579
5467584
5467628
5467633
5467654
5467661
5467685
5467689
5467810
5467849
5467882
5467884
5467940
5467978
5468018
5468140
5468144
5468146
5468172
5468190
5468207
5468209
5468212
5468228
5468244
5468250
5468719
5468746
5468752
5468775
5468788
5468791
5468795
5468825
5468838
5468841
5468845
5468884
5468894
5468899
5468923
5468928
5468947
5469006
5469019
5469028
5469043
5469060
5469067
5469399
5469404
5469453
5469458
5469514
5469517
5469532
5469535
5469551
5469554
5469570
5469574
5469594
5469597
5469636
5469639
5469654
5469657
5469673
5469676
5469692
5469695
5469711
5469716
5469739
5469742
5469758
5469762
5469856
5470381
5470392
5470733
5470735
5470965
5470970
5471009
5471014
5471331
5471335
5471898
5471909
5472252
5472254
5472283
5472285
5472327
5472331
5473127
5473132
5473153
5473158
5473210
5473214
5473659
5473776
5473826
5475172
5475182
5475269
5475272
5475295
5475313
5475353
5475356
5475428
5475431
5475456
5475466
5475474
5475619
5475622
5476504
5476509
5476721
5476726
5476788
5476807
5476810
5476815
5476833
5476853
5476856
5476861
5476947
5477035
5477040
5477182
5477225
5477228
5477235
5477292
5477299
5478278
5478284
5478305
5478312
5478363
5478369
5478390
5478397
5478450
5479185
5479187

# IfcFlowFitting: PVC Corrugado Amarelo_Caixa de Luz 4x2:Linha Eletroduto Corrugado (Amarelo) (31)
In: Planta Baixa - Elétrico
Type - Material: Linha Corrugado PVC Amarelo Antichamas
Type - Pset_DistributionFlowElementCommon - Reference: Linha Eletroduto Corrugado (Amarelo)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre linha Tigreflex ou equivalente
Type - Pset_QuantityTakeOff - Reference: Linha Eletroduto Corrugado (Amarelo)
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (PVC Corrugado Amarelo_Caixa de Luz 4x2:Linha Eletroduto Corrugado (Amarelo):...)
5464059
5464084
5464109
5464134
5466035
5466060
5466085
5466110
5466135
5466160
5466352
5466464
5466490
5467420
5467445
5467470
5467833
5467836
5467839
5467866
5467869
5467872
5468157
5468160
5468163
5468175
5468178
5468181
5468193
5468196
5468199

# IfcFlowFitting: PVC Corrugado Amarelo_Caixa de Luz 4x2:PVC Corrugado Amarelo_Caixa de Luz 4x2 (81)
In: Planta Baixa - Elétrico
Type - Material: Linha Corrugado PVC Amarelo Antichamas
Type - Pset_DistributionFlowElementCommon - Reference: PVC Corrugado Amarelo_Caixa de Luz 4x2
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre linha Tigreflex ou equivalente
Type - Pset_QuantityTakeOff - Reference: PVC Corrugado Amarelo_Caixa de Luz 4x2
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (PVC Corrugado Amarelo_Caixa de Luz 4x2:PVC Corrugado Amarelo_Caixa de Luz 4x2:...)
5458434
5458503
5458571
5458684
5458755
5458780
5458805
5458830
5458855
5458880
5458922
5458978
5459004
5459030
5459056
5459104
5460535
5460560
5460585
5460610
5460710
5460762
5460788
5461207
5461212
5461217
5461222
5461227
5461232
5461235
5461940
5461945
5461950
5461955
5461960
5461965
5461968
5462033
5462038
5462043
5462048
5462053
5462058
5462061
5462171
5462176
5462181
5462186
5462191
5462196
5462199
5462356
5462495
5463050
5463099
5463124
5463149
5463200
5463225
5463279
5463306
5463760
5463786
5463953
5463978
5464003
5464028
5464184
5464634
5465799
5465827
5465855
5465883
5465935
5465984
5466544
5466569
5466594
5469185
5469214
5471279

# IfcFlowFitting: PVC Corrugado Amarelo_Caixa de Octogonal 4x4:PVC Corrugado Amarelo_Caixa de Octogonal 4x4 (112)
In: Planta Baixa - Elétrico
Type - Material: Linha Corrugado PVC Amarelo Antichamas
Type - Pset_DistributionFlowElementCommon - Reference: PVC Corrugado Amarelo_Caixa de Octogonal 4x4
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre linha Tigreflex ou equivalente
Type - Pset_QuantityTakeOff - Reference: PVC Corrugado Amarelo_Caixa de Octogonal 4x4
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (PVC Corrugado Amarelo_Caixa de Octogonal 4x4:PVC Corrugado Amarelo_Caixa de Octogonal 4x4:...)
5457599
5457622
5457779
5457782
5457802
5457805
5457810
5457813
5457831
5457834
5457839
5457842
5457858
5457861
5457866
5457869
5457910
5457950
5460375
5460398
5460421
5460444
5460467
5460490
5461189
5461192
5461195
5461198
5461201
5461204
5461379
5461427
5461922
5461925
5461928
5461931
5461934
5461937
5462015
5462018
5462021
5462024
5462027
5462030
5462153
5462156
5462159
5462162
5462165
5462168
5463835
5463859
5463883
5463907
5464561
5464585
5465110
5465133
5465156
5465179
5465202
5465225
5465248
5465271
5465294
5465317
5465340
5465363
5465386
5465409
5465432
5465455
5465478
5475765
5476011
5476034
5476057
5476080
5476103
5476126
5476149
5476287
5476310
5476333
5476356
5476379
5476402
5476425
5476448
5476533
5476556
5476579
5476602
5476625
5476648
5476671
5477085
5477108
5477457
5477544
5477897
5477921
5477945
5477969
5477993
5478017
5478047
5478071
5478095
5478119
5478143
5478167

# IfcFlowSegment: Conduite sem conexões:Eletroduto Flexivel Corrugado Reforçado de PVC Laranja_Tigreflex (54)
In: Planta Baixa - Elétrico
Type - PredefinedType: CONDUITSEGMENT
Type - Pset_DistributionFlowElementCommon - Reference: Eletroduto Flexivel Corrugado Reforçado de PVC Laranja_Tigreflex
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre ou equivalente
Type - Pset_QuantityTakeOff - Reference: Eletroduto Flexivel Corrugado Reforçado de PVC Laranja_Tigreflex
Pset_DistributionFlowElementCommon - sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Conduite sem conexões:Eletroduto Flexivel Corrugado Reforçado de PVC Laranja_Tigreflex:...) | Length (m)
5476193 | 3.44995
5476203 | 4.05248
5476213 | 3.78217
5476223 | 3.95532
5476235 | 3.91995
5476245 | 3.91537
5476257 | 3.91066
5476484 | 3.29622
5476494 | 0.144969
5476502 | 0.144969
5476701 | 1.70592
5476711 | 0.14436
5476719 | 0.14436
5476728 | 3.02362
5476768 | 1.57926
5476777 | 0.618911
5476791 | 0.618708
5476803 | 0.252759
5476804 | 0.0655404
5476818 | 1.28603
5476825 | 0.952346
5476837 | 0.117631
5476849 | 0.253203
5476850 | 0.0662924
5476864 | 2.96368
5476872 | 2.94864
5476882 | 2.93552
5476894 | 2.92128
5476904 | 0.898215
5476939 | 0.381082
5477005 | 4.17104
5477015 | 6.55841
5477025 | 0.145445
5477033 | 0.145445
5477042 | 7.42698
5477138 | 1.78107
5477174 | 2.03619
5477185 | 2.71419
5477195 | 2.72809
5477204 | 1.87561
5477221 | 0.095552
5477222 | 0.0665072
5477274 | 2.11776
5477290 | 0.101494
5477306 | 8.6345
5477326 | 9.26989
5477487 | 2.13846
5477500 | 0.132739
5477507 | 0.132468
5478812 | 0.0186148
5478987 | 1.24784
5478996 | 1.4708
5479139 | 0.164
5479406 | 0.792678

# IfcFlowSegment: Conduite sem conexões:Eletroduto Flexivel Corrugado de PVC amarelo_Tigreflex (510)
In: Planta Baixa - Elétrico
Type - PredefinedType: CONDUITSEGMENT
Type - Pset_DistributionFlowElementCommon - Reference: Eletroduto Flexivel Corrugado de PVC amarelo_Tigreflex
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre ou equivalente
Type - Pset_QuantityTakeOff - Reference: Eletroduto Flexivel Corrugado de PVC amarelo_Tigreflex
Pset_DistributionFlowElementCommon - sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Conduite sem conexões:Eletroduto Flexivel Corrugado de PVC amarelo_Tigreflex:...) | Length (m)
5457726 | 3.9284
5457784 | 3.9284
5457807 | 3.9284
5457815 | 3.9284
5457836 | 3.9284
5457844 | 3.9284
5457863 | 3.9284
5457871 | 3.9284
5457986 | 1.44244
5458001 | 0.138385
5458008 | 0.13757
5458018 | 0.881036
5458033 | 0.253561
5458034 | 0.0669058
5458045 | 0.253561
5458046 | 0.0669058
5458059 | 1.8564
5458069 | 1.8564
5458079 | 1.8564
5458093 | 1.8564
5458103 | 1.8564
5458161 | 1.8564
5459176 | 1.7729
5459186 | 0.143464
5459197 | 1.60926
5459214 | 0.834761
5459227 | 0.131404
5459234 | 2.40926
5459244 | 1.12662
5459257 | 0.127994
5459264 | 2.40926
5459273 | 1.08802
5459283 | 0.13547
5459290 | 2.40926
5459308 | 0.113854
5459315 | 1.30991
5459332 | 1.60926
5459358 | 0.994395
5459374 | 0.990282
5459392 | 0.990282
5459417 | 5.5712
5459470 | 2.5106
5459480 | 5.58602
5459521 | 2.31672
5459531 | 0.614647
5459546 | 0.409258
5459557 | 0.46504
5459591 | 0.0750368
5459594 | 6.87361
5459614 | 0.409258
5459686 | 0.108604
5459700 | 0.433746
5459716 | 0.409258
5459727 | 0.524181
5459753 | 0.0742227
5459756 | 1.56656
5459776 | 0.409258
5459785 | 0.377077
5459800 | 0.0750245
5459803 | 0.148426
5459824 | 0.409258
5459861 | 0.229
5459870 | 0.00693622
5459896 | 0.369
5459905 | 0.0389362
5459952 | 0.8222
5459962 | 1.015
5459970 | 1.90615
5459980 | 1.015
5459988 | 0.4712
5459998 | 1.015
5460013 | 1.82343
5460023 | 1.015
5460845 | 1.7084
5460855 | 1.6884
5460865 | 1.7084
5460890 | 1.6884
5460900 | 3.7784
5460910 | 1.71133
5460920 | 0.140717
5460927 | 1.60926
5460946 | 1.06321
5460956 | 0.144874
5460963 | 2.40926
5460972 | 1.69732
5460984 | 0.143585
5460991 | 2.40926
5461000 | 1.33214
5461010 | 0.13905
5461017 | 2.40926
5461041 | 1.83902
5461237 | 1.7084
5461239 | 1.7684
5461241 | 1.7084
5461243 | 1.7684
5461245 | 3.7784
5461247 | 1.71133
5461249 | 0.140717
5461250 | 1.60926
5461263 | 1.69135
5461265 | 0.143585
5461266 | 2.40926
5461271 | 1.33214
5461273 | 0.13905
5461274 | 2.40926
5461279 | 1.87892
5461323 | 1.0761
5461335 | 0.145397
5461342 | 2.40926
5461970 | 1.7084
5461972 | 1.6884
5461974 | 1.7084
5461976 | 1.6884
5461978 | 3.7784
5461980 | 1.71133
5461982 | 0.140717
5461983 | 1.60926
5461988 | 1.06321
5461990 | 0.144874
5461991 | 2.40926
5461996 | 1.69732
5461998 | 0.143585
5461999 | 2.40926
5462004 | 1.33214
5462006 | 0.13905
5462007 | 2.40926
5462012 | 1.83902
5462063 | 1.7084
5462065 | 1.7684
5462067 | 1.7084
5462069 | 1.7684
5462071 | 3.7784
5462073 | 1.71133
5462075 | 0.140717
5462076 | 1.60926
5462081 | 1.69135
5462083 | 0.143585
5462084 | 2.40926
5462089 | 1.33214
5462091 | 0.13905
5462092 | 2.40926
5462097 | 1.87892
5462099 | 1.0761
5462101 | 0.145397
5462102 | 2.40926
5462201 | 1.7084
5462203 | 1.6884
5462205 | 1.7084
5462207 | 1.6884
5462209 | 3.7784
5462219 | 1.06321
5462221 | 0.144874
5462222 | 2.40926
5462227 | 1.69732
5462229 | 0.143585
5462230 | 2.40926
5462235 | 1.05233
5462237 | 0.469652
5462238 | 2.40926
5462243 | 1.83902
5462310 | 1.69917
5462320 | 0.143008
5462327 | 1.60926
5462532 | 0.731395
5462542 | 0.141022
5462549 | 1.10926
5462558 | 0.721501
5462568 | 0.142013
5462575 | 1.10926
5462589 | 1.8384
5462599 | 1.19429
5462609 | 0.124527
5462614 | 1.90291
5462644 | 1.47356
5462663 | 0.888207
5462672 | 0.798038
5462703 | 0.314859
5462718 | 0.0751954
5462728 | 0.409258
5462749 | 0.406398
5462758 | 2.75384
5462773 | 0.409258
5462777 | 0.381138
5462789 | 0.0750606
5462792 | 2.46896
5462810 | 0.409258
5462819 | 0.36731
5462835 | 0.409258
5463350 | 5.84772
5463360 | 1.66675
5463370 | 0.144803
5463377 | 2.40926
5463396 | 1.56259
5463412 | 0.792605
5463420 | 1.6577
5463430 | 0.143583
5463437 | 2.40926
5463446 | 1.86029
5463456 | 0.128369
5463463 | 1.60926
5463472 | 1.86601
5463482 | 0.128753
5463489 | 1.60926
5463498 | 1.47729
5463528 | 1.0707
5463603 | 0.231182
5463615 | 0.0732021
5463618 | 5.9738
5463636 | 0.409258
5463646 | 0.302165
5463661 | 0.409258
5463669 | 1.8384
5463679 | 0.68127
5463691 | 0.111091
5463707 | 10.5357
5464221 | 3.17839
5464229 | 2.4284
5464239 | 2.4284
5464249 | 1.18981
5464259 | 0.134427
5464266 | 2.40926
5464287 | 1.51323
5464313 | 1.72788
5464323 | 0.123176
5464330 | 2.40926
5464339 | 0.188934
5464348 | 1.00102
5464362 | 1.60926
5464378 | 0.925448
5464388 | 0.136308
5464393 | 0.66048
5464404 | 2.40926
5464426 | 0.331699
5464442 | 0.317542
5464458 | 0.343823
5464471 | 1.409
5464478 | 8.958
5464489 | 9.79074
5464514 | 2.16434
5464524 | 0.144861
5464531 | 2.40926
5464689 | 1.95653
5464698 | 0.692469
5464712 | 0.133261
5464756 | 2.11157
5464771 | 1.11118
5464781 | 0.126125
5464788 | 1.60926
5464814 | 2.69945
5464842 | 0.49675
5464858 | 0.409258
5464876 | 0.496388
5464888 | 0.0722376
5464891 | 2.80505
5464912 | 0.409258
5464967 | 0.756703
5464975 | 9.46528
5465010 | 0.407381
5465026 | 0.409258
5465045 | 0.403443
5465057 | 0.0157101
5465060 | 2.24745
5465081 | 0.409258
5466926 | 1.78512
5466938 | 0.130603
5466945 | 0.132776
5466956 | 2.17152
5466967 | 0.0958817
5466968 | 0.0699581
5466979 | 0.114803
5467000 | 1.78905
5467010 | 0.131359
5467017 | 0.131949
5467028 | 2.03804
5467038 | 0.136897
5467045 | 0.136203
5467055 | 2.03561
5467065 | 0.136853
5467072 | 0.136156
5467082 | 0.229
5467089 | 0.658
5467100 | 3.28977
5467125 | 1.8584
5467135 | 1.8784
5467145 | 0.735662
5467155 | 0.144917
5467162 | 1.60926
5467171 | 0.736025
5467181 | 0.128068
5467188 | 1.60926
5467197 | 0.735891
5467207 | 0.14555
5467214 | 1.60926
5467223 | 0.694264
5467233 | 0.135497
5467240 | 1.60926
5467249 | 1.81383
5467259 | 0.137996
5467266 | 2.40926
5467316 | 0.779168
5467357 | 2.82723
5467522 | 1.46599
5467532 | 0.144859
5467537 | 0.804071
5467548 | 0.128327
5467560 | 0.779489
5467570 | 0.140892
5467577 | 1.60926
5467609 | 0.976807
5467619 | 0.140547
5467626 | 1.60926
5467635 | 2.04009
5467645 | 0.140183
5467652 | 0.121108
5467663 | 0.501018
5467673 | 0.118372
5467680 | 1.60926
5467708 | 0.689661
5467726 | 0.722388
5467806 | 0.0832309
5467807 | 0.0249524
5467841 | 0.689661
5467843 | 0.722388
5467847 | 0.0832309
5467848 | 0.0249524
5467874 | 0.689661
5467876 | 0.722388
5467880 | 0.0832309
5467881 | 0.0249524
5467926 | 0.285292
5467951 | 0.323792
5467960 | 1.471
5467995 | 0.323792
5468004 | 1.4815
5468020 | 0.1435
5468126 | 0.21199
5468138 | 2.3383
5468165 | 0.689661
5468167 | 0.722388
5468170 | 0.0832309
5468171 | 0.0249524
5468183 | 0.689661
5468185 | 0.722388
5468188 | 0.0832309
5468189 | 0.0249524
5468201 | 0.689661
5468203 | 0.722388
5468205 | 0.0832309
5468206 | 0.0249524
5468211 | 0.285292
